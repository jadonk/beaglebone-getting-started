# Allegro board BeagleBone_revC1_ALLEGRO.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_D1: length 27.1
  TOP w0.121: U6.G2 v1(69.13,35.49)
  BOTTOM w0.121: v1(69.13,35.49) 68.73,35.09 68.73,34.52 68.5,34.29 65.41,34.29 64.14,35.56 63.75,35.56 63.63,35.69 63.63,35.94 63.75,36.07 64.01,36.07 64.14,36.2 64.14,36.45 64.01,36.58 63.75,36.58 63.63,36.7 63.63,36.96 63.75,37.08 64.15,37.08 64.27,37.21 64.27,41.4 64.15,41.53 63.75,41.53 63.63,41.4 63.63,39.88 63.5,39.76 62.85,39.76 62.85,39.76 62.65,39.76 62.36,39.76 62.23,39.63 62.23,39.24 62.36,39.12 63.75,39.12 63.88,38.99 63.88,38.73 63.75,38.61 63.37,38.61 63.25,38.48 63.25,38.23 63.37,38.1 63.75,38.1 63.88,37.97 63.88,37.59 63.75,37.47 R45.1
DDR_D2: length 27
  TOP w0.121: U6.H7 v1(73.93,34.69) ; R46.1 61.79,40.32 v1(62.23,40.77)
  LYR3 w0.121: 75.86,35.09 74.9,35.09 74.33,35.09 v1(73.93,34.69)
  LYR3 w0.133: v1(62.23,40.77) 63.63,42.16 63.63,42.8 64.14,43.31 69.47,43.31 69.98,43.81 73.79,43.81 76.2,41.4 76.2,35.43 75.86,35.09
DDR_D3: length 27.1
  TOP w0.121: v1(66.04,41.27) R47.1 ; U6.H3 v1(69.93,34.69)
  LYR3 w0.133: v1(66.04,41.27) 66.45,41.68 67.03,41.68 67.69,41.02 69.9,41.02 71.88,39.04 71.88,34.82 71.75,34.69 71.5,34.69 71.37,34.82 71.37,38.86 71.25,38.99 70.99,38.99 70.87,38.86 70.87,34.82 70.74,34.69 v1(69.93,34.69)
DDR_D4: length 27
  TOP w0.121: U6.H1 v1(68.33,34.69)
  BOTTOM w0.121: v1(68.33,34.69) 65.39,34.69 64.52,35.55 64.52,41.02 64.65,41.15 65.15,41.15 65.28,41.27 65.28,41.66 65.15,41.78 63.75,41.78 63.63,41.91 63.63,42.67 63.5,42.8 63.25,42.8 63.12,42.67 63.12,40.13 62.99,40.01 62.1,40.01 61.98,39.88 61.98,38.99 62.1,38.86 62.61,38.86 62.74,38.73 62.74,37.97 62.61,37.85 61.47,37.85 61.34,37.97 61.34,38.73 61.21,38.86 61.09,38.86 60.96,38.73 60.96,37.97 60.83,37.85 60.58,37.85 60.45,37.97 60.45,38.75 60.34,38.86 60.18,38.86 60.07,38.75 60.07,38.54 59.94,38.42 R48.1
DDR_D5: length 27.1
  TOP w0.121: v1(75.53,34.69) 75.53,34.69 U6.H9
  LYR3 w0.133: v1(62.23,38.35) 62.23,38.61 64.64,41.02 65.15,41.02 66.05,41.92 67.18,41.92 67.82,41.27 69.98,41.27 72.14,39.12 72.14,34.16 72.52,33.78 76.07,33.78 76.33,34.04 76.33,34.44 76.07,34.69 v1(75.53,34.69)
  BOTTOM w0.121: R49.1 61.21,39.37 v1(62.23,38.35)
DDR_D6: length 27.2
  TOP w0.121: U6.F1 v1(68.33,36.29)
  BOTTOM w0.121: R50.1 60.58,40.32 60.71,40.45 60.71,40.89 60.83,41.02 61.59,41.02 61.72,40.89 61.72,40.45 61.85,40.32 62.61,40.32 62.74,40.45 62.74,42.16 62.61,42.29 60.2,42.29 60.07,42.42 60.07,42.93 60.2,43.05 63.75,43.05 63.88,42.93 63.88,42.16 64.01,42.04 65.41,42.04 65.53,41.91 65.53,41.02 65.41,40.89 64.9,40.89 64.77,40.77 64.77,39.88 64.9,39.75 65.41,39.75 65.53,39.62 65.53,39.37 65.41,39.24 64.9,39.24 64.77,39.12 64.77,36.58 65.06,36.29 v1(68.33,36.29)
DDR_D7: length 26.9
  TOP w0.121: U6.F9 75.53,36.29 v1(75.53,36.29)
  LYR3 w0.133: v1(75.53,36.29) 75.95,36.7 75.95,41.27 73.66,43.56 70.1,43.56 69.6,43.05 65.66,43.05 64.64,42.04 64.14,42.04 62.33,40.23 61.85,40.23 61.59,40.49 61.59,41.15 v1(62.23,41.78)
  BOTTOM w0.121: v1(62.23,41.78) 60.58,41.78 60.07,41.27 R51.1
DDR_D8: length 27.2
  TOP w0.121: R52.1 61.72,33.66 v1(63.12,35.05) ; v1(74.73,37.89) 74.33,38.29 U6.C8
  LYR3 w0.121: v1(74.73,37.89) 74.73,37.92 73.41,39.24 73.15,39.24
  LYR3 w0.133: 73.15,39.24 70.36,42.04 68.2,42.04 67.56,42.67 65.66,42.67 64.77,41.78 64.26,41.78 60.2,37.72 60.2,35.81 61.37,34.65 62.71,34.65 v1(63.12,35.05)
DDR_D9: length 26.9
  TOP w0.121: U6.C2 v1(69.13,38.69) ; R53.1 61.79,34.61 v1(62.23,35.05)
  LYR3 w0.121: 68.07,38.29 68.73,38.29 v1(69.13,38.69)
  LYR3 w0.133: v1(62.23,35.05) 61.47,35.05 60.58,35.94 60.58,37.59 60.71,37.72 60.96,37.72 61.09,37.59 61.09,36.2 61.62,35.66 62.61,35.66 62.71,35.76 62.71,36.42 62.84,36.55 63.4,36.55 63.75,36.2 64.74,36.2 64.87,36.32 64.87,37.72 65,37.85 65.66,37.85 65.79,37.72 65.79,34.29 65.91,34.16 66.17,34.16 66.29,34.29 66.29,38.73 66.42,38.86 67.69,38.86 67.82,38.73 67.82,38.42 67.94,38.29 68.07,38.29
DDR_D10: length 27.3
  TOP w0.121: v1(71.75,42.55) 71.75,40.89 71.63,40.77 68.04,40.77 67.69,40.42 67.69,36.2 67.4,35.91 63.75,35.91 63.41,35.56 R54.1 ; U6.D7 72.79,37.49 72.67,37.62 72.67,40.92 72.77,41.02 74.42,41.02 74.55,41.15 74.55,42.42 74.42,42.55 v1(72.9,42.55)
  LYR3 w0.133: v1(72.9,42.55) v1(71.75,42.55)
DDR_D11: length 26.9
  TOP w0.121: U6.D3 v1(69.93,37.89)
  LYR3 w0.121: 67.94,37.49 69.53,37.49 v1(69.93,37.89)
  LYR3 w0.133: v1(64.01,35.05) 63.75,35.05 62.99,34.29 60.07,34.29 59.94,34.16 59.94,33.66 60.07,33.53 63.47,33.53 63.6,33.66 63.6,34.04 63.73,34.16 64.29,34.16 64.41,34.04 64.41,33.63 64.52,33.53 65.66,33.53 65.79,33.4 65.79,33.02 65.91,32.89 66.93,32.89 67.06,33.02 67.06,34.29 67.18,34.42 67.69,34.42 67.82,34.54 67.82,37.36 67.94,37.49
  BOTTOM w0.121: R55.1 60.13,32.7 62.08,34.65 63.61,34.65 v1(64.01,35.05)
DDR_D12: length 27.3
  TOP w0.121: U6.D1 v1(68.33,37.89)
  LYR3 w0.133: v1(63.12,36.07) 63.12,35.69 63.25,35.56 64.52,35.56 64.65,35.43 64.65,33.9 64.77,33.78 65.91,33.78 66.04,33.66 66.04,33.27 66.17,33.15 66.42,33.15 66.55,33.27 66.55,38.35 66.67,38.48 66.93,38.48 67.06,38.35 67.06,34.92 67.18,34.8 67.44,34.8 67.56,34.92 67.56,37.76 67.69,37.89 v1(68.33,37.89)
  BOTTOM w0.121: R56.1 60.1,33.66 60.2,33.76 60.2,34.19 60.3,34.29 60.48,34.29 60.58,34.19 60.58,33.88 60.68,33.78 60.86,33.78 60.96,33.88 60.96,34.92 61.07,35.03 61.24,35.03 61.34,34.92 61.34,34.65 61.44,34.54 61.62,34.54 61.72,34.65 61.72,35.43 61.85,35.56 62.99,35.56 63.12,35.69 v1(63.12,36.07)
DDR_D13: length 27
  TOP w0.121: v1(74.73,37.09) U6.D9
  LYR3 w0.133: v1(62.23,36.07) 61.47,36.83 61.47,38.61 64.39,41.53 64.9,41.53 65.79,42.42 67.44,42.42 68.07,41.78 70.23,41.78 72.64,39.37 72.64,35.94 72.77,35.81 73.03,35.81 73.15,35.94 73.15,36.32 73.41,36.58 74.22,36.58 v1(74.73,37.09)
  BOTTOM w0.121: v1(62.23,36.07) 61.59,36.07 60.13,34.61 R57.1
DDR_D14: length 26.8
  TOP w0.121: U6.B1 v1(68.33,39.49)
  LYR3 w0.133: v1(63.12,36.96) 62.71,37.36 62.36,37.36 62.23,37.49 62.23,37.72 62.36,37.85 62.61,37.85 62.74,37.97 62.74,38.61 62.87,38.73 63.12,38.73 63.25,38.61 63.25,37.59 63.37,37.47 63.63,37.47 63.75,37.59 63.75,39.62 63.88,39.75 64.14,39.75 64.26,39.62 64.26,38.35 64.39,38.23 64.64,38.23 64.77,38.35 64.77,40.64 64.9,40.77 66.8,40.77 67.18,40.39 67.69,40.39 67.82,40.26 67.82,40.01 67.69,39.88 66.67,39.88 66.42,40.13 66.04,40.13 65.79,39.88 65.28,39.88 65.15,39.75 65.15,39.24 65.28,39.12 67.96,39.12 v1(68.33,39.49)
  BOTTOM w0.121: R58.1 60.07,35.56 60.98,36.47 62.63,36.47 v1(63.12,36.96)
DDR_D15: length 26.9
  TOP w0.121: U6.B9 74.73,39.49 74.73,40.22 v1(74.73,40.29) ; v1(69.47,42.55) 68.45,41.53 67.69,41.53 66.93,40.77 66.93,36.83 66.8,36.7 66.42,36.7 66.29,36.83 66.29,38.99 66.17,39.12 64.9,39.12 64.77,38.99 64.77,38 64.64,37.87 64.14,37.87 64.01,38 64.01,38.64 63.88,38.77 62.01,38.77 61.66,38.42 R59.1
  LYR3 w0.133: v1(69.47,42.55) 70.23,43.31 73.41,43.31 73.64,43.07 73.64,42.29 73.79,42.14 74.42,42.14 74.73,41.83 v1(74.73,40.29)
DDR_DQM0: length 27.1
  TOP w0.121: v1(66.8,41.27) 66.67,41.15 66.67,40.26 66.55,40.13 66.29,40.13 66.17,40.26 66.17,40.64 66.04,40.77 65.82,40.77 65.69,40.64 65.69,39.62 65.57,39.5 64.9,39.5 64.77,39.62 64.77,40.77 64.64,40.89 64.39,40.89 64.26,40.77 64.26,39.24 64.14,39.12 63.88,39.12 63.75,39.24 63.75,40.77 63.63,40.89 63.37,40.89 63.25,40.77 63.25,39.24 63.12,39.12 62.87,39.12 62.74,39.24 62.74,40.13 62.61,40.26 62.36,40.26 62.23,40.13 62.23,39.24 62.1,39.12 61.85,39.12 61.59,39.37 R67.1 ; U6.F3 v1(69.93,36.29)
  LYR3 w0.121: v1(69.93,36.29) 70.36,36.29 70.48,36.42 70.48,39.78 70.38,39.88 70.08,39.88 69.98,39.78 69.98,39.22 69.88,39.12 69.63,39.12 69.53,39.22 69.53,40.58
  LYR3 w0.133: v1(66.8,41.27) 67.31,40.77 69.34,40.77 69.53,40.58
DDR_DQM1: length 26.9
  TOP w0.121: U6.B3 70.74,38.68 70.74,35.81 70.87,35.69 71.12,35.69 71.25,35.81 71.25,38.86 71.37,38.99 71.63,38.99 71.75,38.86 71.75,33.66 71.63,33.53 71.37,33.53 71.25,33.66 71.25,35.05 71.12,35.18 70.87,35.18 70.74,35.05 70.74,34.02 70.61,33.89 68.47,33.89 68.2,34.16 63.18,34.16 61.72,32.7 R70.1
DDR_DQS0: length 27
  TOP w0.121: U6.F7 73.03,35.89 72.9,35.76 72.9,34.92 72.77,34.8 72.3,34.8 72.17,34.92 72.17,43.18 72.3,43.31 74.17,43.31 74.3,43.43 74.3,43.69 74.17,43.81 64.9,43.81 63.31,42.23 R68.1
DDR_DQS1: length 27.2
  TOP w0.121: R71.1 62.52,36.51 62.65,36.64 62.65,37.25 62.77,37.37 63.5,37.37 63.63,37.25 63.63,36.32 63.75,36.2 64.14,36.2 64.26,36.32 64.26,37.25 64.39,37.37 64.64,37.37 64.77,37.25 64.77,36.32 64.9,36.2 67.31,36.2 67.44,36.32 67.44,40.51 67.94,41.02 71.25,41.02 71.37,41.15 71.37,42.16 v1(70.99,42.55)
  TOP w0.305: v1(73.13,40.29) 73.04,40.2 73.04,39.58 U6.B7
  LYR3 w0.133: v1(73.13,40.29) 72.77,40.29 72.64,40.42 72.64,41.94 72.54,42.04 72.24,42.04 72.14,41.94 72.14,41.27 72.01,41.15 71.88,41.15 71.75,41.27 71.75,41.78 71.63,41.91 71.12,41.91 70.99,42.04 v1(70.99,42.55)
DDR_DQSN0: length 27.2
  TOP w0.121: R69.1 63.75,43.18 64.64,44.07 74.42,44.07 74.55,43.94 74.55,43.18 74.42,43.05 72.52,43.05 72.42,42.95 72.42,42.16 72.55,42.04 73.28,42.04 73.41,41.91 73.41,41.53 73.28,41.4 72.55,41.4 72.42,41.27 72.42,36.4 72.52,36.29 73.93,36.29 U6.E8
DDR_DQSN1: length 27
  TOP w0.121: R72.1 61.72,37.47 61.88,37.62 65.02,37.62 65.25,37.85 65.91,37.85 66.04,37.72 66.04,36.58 66.17,36.45 67.06,36.45 67.18,36.58 67.18,40.64 67.82,41.27 69.34,41.27 69.47,41.4 69.47,41.91 69.6,42.04 69.72,42.04 69.85,41.91 69.85,41.4 69.98,41.27 70.1,41.27 70.23,41.4 v1(70.23,42.55)
  TOP w0.305: U6.A8 v1(73.93,40.29)
  LYR3 w0.133: v1(70.23,42.55) 70.23,42.93 70.36,43.05 73.15,43.05 73.41,42.8 73.41,42.04 73.53,41.91 74.17,41.91 74.3,41.78 74.3,41.53 74.17,41.4 73.15,41.4 73.03,41.27 73.03,41.02 73.15,40.89 74.04,40.89 74.17,40.77 74.17,40.52 v1(73.93,40.29)
DDR_ODT: length 27.2
  TOP w0.121: v1(62.23,29.84) R73.1 ; U6.K9 v1(75.53,32.29)
  LYR3 w0.121: 73.66,32.69 74.12,32.69 74.33,32.47 74.33,32.12 74.57,31.89 75.13,31.89 v1(75.53,32.29)
  LYR3 w0.133: v1(62.23,29.84) 61.72,29.84 61.59,29.72 61.59,28.96 61.47,28.83 60.45,28.83 60.33,28.96 60.33,33.02 60.45,33.15 64.39,33.15 64.52,33.02 64.52,32.77 64.64,32.64 67.18,32.64 67.31,32.77 67.31,33.91 67.44,34.04 71.5,34.04 71.75,33.78 71.75,32.89 71.96,32.69 73.66,32.69
DDR_RASN: length 27.3
  TOP w0.121: U6.K7 73.93,32.29 v1(73.93,32.29)
  LYR3 w0.133: v1(73.93,32.29) 71.63,32.29 71.5,32.42 71.5,33.66 71.37,33.78 67.69,33.78 67.56,33.66 67.56,32.51 67.44,32.38 65.02,32.38 64.9,32.26 64.9,30.23 64.77,30.1 64.52,30.1 64.39,30.23 64.39,32.13 64.26,32.26 61.72,32.26 61.59,32.13 61.59,30.61 61.72,30.48 62.87,30.48 63.12,30.23 v1(63.12,29.84)
  BOTTOM w0.121: v1(63.12,29.84) 62.61,29.34 60.71,29.34 60.2,29.84 R65.1
DDR_RESETN: length 3.5
  TOP w0.121: U5.G2 55.93,31.89 57.14,31.89 58.23,30.8 TP3.1
DDR_VREF: length 21
  TOP w0.121: U6.J2 v1(69.13,33.09) ; v1(54.33,33.49) U5.J4
  BOTTOM w0.121: v1(54.33,33.49) 54.73,33.09 55.44,33.09 55.63,33.27 57.02,33.27 58.04,32.26 60.33,32.26 60.77,32.7 R74.2 R75.1 62.04,34.04 62.17,34.16 64.77,34.16 65.15,33.78 68.44,33.78 v1(69.13,33.09) 67.93,31.89 C118.1
DDR_VTP: length 18.8
  TOP w0.305: v1(55.13,33.49) U5.J3
  LYR4 w0.381: v1(64.77,20.32) 59.05,26.04 59.05,30.1 55.66,33.49 v1(55.13,33.49)
  BOTTOM w0.381: R76.2 v1(64.77,20.32)
DDR_WEN: length 26.9
  TOP w0.121: v1(68.2,23.62) 67.78,23.21 67.09,23.21 66.26,24.04 63.79,24.04 61.59,21.84 57.15,21.84 56.83,22.16 R66.1 ; U6.K3 v1(69.93,32.29)
  LYR3 w0.133: v1(68.2,23.62) 68.83,24.26 68.83,24.77 69.85,25.78 69.85,26.54 71.25,27.94 71.63,27.94 72.77,29.08 72.77,30.99 72.01,31.75 70.47,31.75 v1(69.93,32.29)
EHRPWM1A: length 54.6
  TOP w0.121: U5.U14 45.53,40.69 45.53,41.34 44.58,42.29 41.66,42.29 40.89,43.05 40.64,43.05 39.5,44.2 v1(36.83,44.2)
  LYR4 w0.133: v1(36.83,44.2) 36.83,42.04 36.32,41.53 36.32,39.12 36.83,38.61 37.34,38.61 38.61,37.34 38.61,35.56 35.69,32.64 35.69,20.95 35.31,20.57 35.31,13.59 34.8,13.08 34.8,9.14 35.69,8.26 35.69,5.21 P9.14
EHRPWM1B: length 44.8
  TOP w0.121: v1(45.53,39.89) U5.T14
  LYR4 w0.133: v1(45.53,39.89) 45.03,40.39 40.26,40.39 39.24,39.37 39.24,38.73 39.5,38.48 39.5,31.62 36.58,28.7 36.58,21.97 37.69,20.85 37.69,19.79 37.47,19.56 37.47,12.32 38.1,11.68 38.1,6.22 37.47,5.59 P9.16
EHRPWM2A: length 29.6
  TOP w0.121: U5.U10 49.53,40.69 49.53,41.61 49.38,41.77 49.38,41.89 46.62,44.65 46.62,47.9 46.51,48.01 46.33,48.01 46.23,47.9 46.23,44.81 46.13,44.7 45.95,44.7 45.85,44.81 45.85,47.9 45.75,48.01 45.57,48.01 45.47,47.9 45.47,44.81 45.36,44.7 45.19,44.7 45.09,44.81 45.09,48.32 44.83,48.58 44.13,48.58 43.69,49.02 43.69,51.05 43.43,51.31 42.8,51.31 42.55,51.05 P8.19
EHRPWM2B: length 28.6
  TOP w0.121: v1(48.73,39.89) U5.T10
  LYR4 w0.133: v1(48.73,39.89) 48.15,40.47 47.8,40.47 44.32,43.94 40.39,43.94 40.13,44.2 40.13,48.01 39.88,48.26 39.5,48.26 39.24,48.01 39.24,47.37 38.99,47.12 38.61,47.12 38.35,47.37 38.35,48.01 38.1,48.26 37.72,48.26 37.47,48.01 37.47,45.47 37.21,45.21 36.45,45.21 36.2,45.47 36.2,48.9 P8.13
EMU2R: length 2.8
  BOTTOM w0.121: R183.2 P7.17
EMU3R: length 4.9
  BOTTOM w0.121: P7.18 68.07,17.14 67.82,17.4 R184.1
EMU4R: length 2.8
  BOTTOM w0.121: R185.2 P7.19
EMU_RSTN: length 4.9
  BOTTOM w0.121: C156.1 60.45,15.11 60.58,15.24 61.21,15.24 61.47,15.49 R182.2 P7.15
ENZ_KALDO_1P8V: length 5.2
  TOP w0.121: U5.B4 53.94,28.29 54.33,27.9 54.33,25.7 54.07,25.44 54.07,24.73 54.1,24.7 54.1,24.64 54.93,23.81 R79.2
F_ADBUS0: length 2.6
  TOP w0.121: v1(48.26,6.35) 48.56,6.35 48.84,6.62 U12.16
  BOTTOM w0.121: v1(48.26,6.35) R164.1
F_ADBUS1: length 5.4
  TOP w0.121: U12.17 51.63,9.58 51.82,9.4 51.82,7.87 v1(52.7,6.99)
  BOTTOM w0.121: v1(52.7,6.99) R165.1
F_ADBUS2: length 4.7
  TOP w0.121: U12.18 51.76,10.09 52.07,9.78 52.07,8.89 v1(52.7,8.26)
  BOTTOM w0.121: R166.1 v1(52.7,8.26)
F_ADBUS3: length 3.9
  TOP w0.121: U12.19 51.65,10.58 v1(52.7,9.53)
  BOTTOM w0.121: v1(52.7,9.53) R168.1
F_ADBUS4: length 3.7
  TOP w0.121: v1(52.7,10.79) 51.92,11.58 U12.21
  BOTTOM w0.121: v1(52.7,10.79) R169.1
F_ADBUS5: length 3.6
  TOP w0.121: v1(52.32,14.09) U12.26
  BOTTOM w0.121: R172.1 52.84,14.61 v1(52.32,14.09)
F_ADBUS6: length 3.6
  TOP w0.121: U12.23 52.19,12.58 v1(52.7,12.06)
  BOTTOM w0.121: v1(52.7,12.06) R170.1
F_ADBUS7: length 5.9
  TOP w0.121: v1(52.7,13.34) 52.7,13.72 52.83,13.84 52.83,15.24 51.99,16.09 U12.30
  BOTTOM w0.121: v1(52.7,13.34) R171.1
F_EECS: length 5.7
  TOP w0.121: R173.2 v1(36.51,8.89) 37.59,8.89 38.1,9.4 38.1,9.84 38.34,10.09 U12.63
  BOTTOM w0.121: v1(36.51,8.89) U13.5
F_EEDATA: length 8.1
  TOP w0.121: U12.61 37.25,11.09 36.96,10.79 v1(36.51,10.79) R188.2
  BOTTOM w0.121: v1(36.51,10.79) 34.92,10.79 33.97,9.84 U13.3
F_EEDOUT: length 8
  TOP w0.121: R187.2 33.88,7.94 33.66,7.72 v1(33.66,6.99) ; R188.1 v1(33.66,10.79)
  LYR4 w0.133: v1(33.66,10.79) v1(33.66,6.99)
  BOTTOM w0.121: v1(33.66,6.99) 33.91,7.24 33.91,7.75 33.72,7.94 U13.1
F_EESK: length 5.3
  TOP w0.121: R174.2 v1(36.51,9.84) 37.25,10.58 U12.62
  BOTTOM w0.121: v1(36.51,9.84) U13.4
FT_DM: length 53.5
  TOP w0.114: 44.33,8.72 44.56,8.94 44.56,13.09 42.14,15.51 42.14,16.27 39.69,18.72 39.69,20.13 38.51,21.31 36.86,21.31 35.56,22.61 35.56,27.8 35.28,28.08 35.28,34.43 34.29,35.42 34.29,36.07 32.54,37.82 23.99,37.82 22.49,36.32 20.18,36.32 18.26,38.24 18.26,39.1 18.55,39.4 U11.28
  TOP w0.121: 44.33,8.72 U12.7
FT_DP: length 53.5
  TOP w0.114: 44.84,8.72 44.84,13.2 42.42,15.62 42.42,16.38 39.97,18.83 39.97,20.25 38.62,21.59 36.97,21.59 35.84,22.72 35.84,27.91 35.56,28.19 35.56,34.54 34.57,35.53 34.57,36.18 32.65,38.1 23.88,38.1 22.38,36.6 20.29,36.6 18.54,38.35 18.54,38.99 18.67,39.12 18.89,39.12 19.14,38.87 U11.1
  TOP w0.121: 44.84,8.72 U12.8
FT_REF: length 2.3
  TOP w0.121: U12.6 43.84,6.65 v1(44.13,6.35)
  BOTTOM w0.121: R167.2 v1(44.13,6.35)
FT_RESETN: length 2.8
  TOP w0.121: U12.14 v1(47.84,9.53)
  BOTTOM w0.121: 48.26,10.29 48.26,9.75 48.04,9.53 v1(47.84,9.53)
FT_SRESET: length 47.2
  TOP w0.121: U14.5 34.43,25.29 33.97,24.83 v1(33.97,24.77)
  LYR3 w0.133: v1(32.13,11.75) 32.7,12.32 38.73,12.32 41.66,15.24 52.07,15.24 v1(52.32,14.99)
  LYR4 w0.133: v1(32.13,11.75) 34.54,14.16 34.54,20.57 34.04,21.08 34.04,22.92 33.46,23.5 33.46,24.26 v1(33.97,24.77)
  BOTTOM w0.121: v1(52.32,14.99) 52.58,15.24 54.86,15.24 55.12,14.99 R172.2 58.55,14.61 59.82,15.88 R182.1 ; v1(33.97,24.77) R162.2
FT_SRESETB: length 1.9
  TOP w0.121: U16.6 34.12,42.97 33.91,43.18 v1(33.53,43.18)
  BOTTOM w0.121: v1(33.53,43.18) R163.1
FT_SRESETN: length 23
  TOP w0.121: U16.1 31.1,42.56 30.86,42.8 v1(30.86,43.18) ; U14.3 32.39,25.79 32.64,26.04 32.64,27.43 32.35,27.72 31.53,27.72 v1(31.11,27.3)
  LYR4 w0.133: v1(30.86,43.18) 29.59,41.91 29.59,39.5 30.73,38.35 30.73,27.69 v1(31.11,27.3)
FT_VBUS: length 50.8
  TOP w0.121: U11.7 22.87,38.87 23.24,39.24 27.69,39.24 28.45,40.01 v1(30.1,40.01) ; v1(32.89,11.75) 33.46,12.32 35.18,12.32 35.43,12.06 R181.2 36.13,11.75 36.47,12.09 U12.59 ; U14.6 33.15,25.79 v1(32.13,24.77)
  LYR4 w0.133: v1(30.1,40.01) 30.99,39.12 30.99,28.19 31.62,27.56 31.62,26.42 32.13,25.91 v1(32.13,24.77) 32.13,23.88 32.77,23.24 33.27,23.24 33.53,22.99 33.53,19.05 31.62,17.14 31.62,11.56 31.88,11.3 32.45,11.3 v1(32.89,11.75)
GPIO0_7: length 52.1
  TOP w0.121: U5.C18 42.04,29.09 41.31,28.36 40.29,28.36 40.01,28.07 40.01,23.5 41.91,21.59 44.2,21.59 45.47,20.32 v1(45.97,20.32)
  BOTTOM w0.121: P9.42 69.34,5.59 52.45,5.59 51.31,6.73 51.31,11.68 50.8,12.19 48.77,12.19 47.18,13.78 47.18,16.83 45.97,18.03 v1(45.97,20.32)
GPIO0_26: length 29.2
  TOP w0.121: v1(47.93,39.89) U5.T11
  LYR3 w0.133: v1(47.93,39.89) 43.75,44.07 39.5,44.07 39.24,44.32 39.24,44.83 39.5,45.09 42.49,45.09 42.67,45.27 42.67,45.53 42.49,45.72 v1(36.83,45.72)
  LYR4 w0.133: P8.14 36.07,51.56 36.07,49.78 36.83,49.02 v1(36.83,45.72)
GPIO0_27: length 29.5
  TOP w0.121: P8.17 38.61,48.77 37.72,48.77 37.59,48.64 37.59,45.34 37.72,45.21 37.97,45.21 38.1,45.34 38.1,47.88 38.23,48.01 38.48,48.01 38.61,47.88 38.61,45.34 38.73,45.21 38.99,45.21 39.12,45.34 39.12,47.88 39.24,48.01 39.5,48.01 39.62,47.88 39.62,45.18 40.99,43.81 42.55,43.81 42.8,43.56 44.96,43.56 47.13,41.39 47.13,40.69 U5.U12
GPIO1_0: length 11.7
  TOP w0.121: P8.25 49.05,49.05 49.05,44.32 51.93,41.44 51.93,40.69 U5.U7
GPIO1_1: length 14.1
  TOP w0.121: U5.V7 51.53,41.49 47.88,45.14 47.88,48.51 48.9,49.53 48.9,51.44 P8.24
GPIO1_2: length 32
  TOP w0.121: v1(51.13,39.09) U5.R8
  LYR3 w0.121: 50.73,40.33 50.73,39.49 v1(51.13,39.09)
  LYR3 w0.133: 50.73,40.33 44.32,46.74 31.75,46.74 30.23,48.26 26.67,48.26 P8.5
GPIO1_3: length 33.5
  TOP w0.121: v1(51.13,39.89) U5.T8
  LYR3 w0.133: v1(51.13,39.89) 51.13,40.31 44.45,46.99 32,46.99 30.48,48.51 27.3,48.51 26.04,49.78 26.04,51.44 P8.6
GPIO1_4: length 11.5
  TOP w0.121: U5.U8 51.13,40.69 51.13,41.54 47.62,45.05 P8.23
GPIO1_5: length 14
  TOP w0.121: P8.22 46.35,51.44 46.35,49.53 47.37,48.51 47.37,44.95 50.27,42.05 50.73,41.59 U5.V8
GPIO1_6: length 33.8
  TOP w0.121: v1(50.33,39.09) U5.R9
  LYR3 w0.133: P8.3 26.16,46.23 42.67,46.23 46.61,42.29 48.01,42.29 49.91,40.39 49.91,39.51 v1(50.33,39.09)
GPIO1_7: length 35.4
  TOP w0.121: v1(50.33,39.89) U5.T9
  LYR3 w0.133: v1(50.33,39.89) 50.33,40.35 44.2,46.48 26.42,46.48 23.5,49.4 23.5,51.44 P8.4
GPIO1_12: length 28.9
  TOP w0.121: v1(47.13,39.89) U5.T12
  LYR4 w0.133: P8.12 31.11,51.44 31.11,48.26 34.67,44.7 37.72,44.7 37.97,44.96 37.97,46.23 38.23,46.48 38.61,46.48 38.86,46.23 38.86,43.68 39.11,43.43 43.94,43.43 47.13,40.25 v1(47.13,39.89)
GPIO1_13: length 28.8
  TOP w0.121: v1(47.13,39.09) U5.R12
  LYR3 w0.121: 46.73,40.27 46.73,39.49 v1(47.13,39.09)
  LYR3 w0.133: v1(35.69,45.72) 35.69,43.94 36.07,43.56 39.62,43.56 39.88,43.31 39.88,43.05 39.62,42.8 37.14,42.8 36.96,42.61 36.96,42.35 37.14,42.16 39.37,42.16 40.13,41.4 40.89,41.4 41.66,42.16 44.83,42.16 46.73,40.27
  LYR4 w0.133: P8.11 35.69,46.86 v1(35.69,45.72)
GPIO1_14: length 29.5
  TOP w0.121: U5.V13 46.73,41.41 44.83,43.31 42.67,43.31 42.42,43.56 40.89,43.56 39.6,44.86 37.37,44.86 37.25,44.99 37.25,48.54 37.14,48.64 36.8,48.64 36.7,48.54 36.7,47.35 36.6,47.24 36.42,47.24 36.32,47.35 36.32,48.54 36.22,48.64 36.04,48.64 35.94,48.54 35.94,47.35 35.84,47.24 35.53,47.24 35.43,47.35 35.43,49.05 35.53,49.15 38.35,49.15 38.73,49.53 38.73,51.44 P8.16
GPIO1_15: length 29.6
  TOP w0.121: U5.U13 46.33,40.69 46.33,41.43 44.7,43.05 42.55,43.05 42.29,43.31 40.74,43.31 39.43,44.61 36.39,44.61 36.1,44.9 36.1,46.19 33.79,48.51 31.5,48.51 31.24,48.76 31.24,51.31 31.5,51.56 36.07,51.56 P8.15
GPIO1_16: length 49.4
  TOP w0.121: v1(46.33,39.09) U5.R13
  LYR4 w0.121: v1(46.33,39.09) 46.33,39.27 45.93,39.67 45.93,40.09
  LYR4 w0.133: 45.93,40.09 45.93,40.18 45.47,40.64 40.01,40.64 38.86,39.5 38.86,38.61 39.12,38.35 39.12,33.78 38.54,33.21 38.54,31.18 36.32,28.96 36.32,20.95 36.7,20.57 36.7,14.22 36.96,13.97 36.96,5.71 36.32,5.08 36.32,3.05 P9.15
GPIO1_17: length 57.8
  TOP w0.121: v1(41.91,42.8) 44.58,42.8 45.93,41.45 U5.V14
  LYR4 w0.121: 46.48,40.39 46.73,40.14 46.73,39.61 46.73,38.92 46.5,38.69 46.16,38.69 45.93,38.93 45.93,39.29 45.73,39.49 43.43,39.49
  LYR4 w0.133: v1(41.91,42.8) 44.07,42.8 46.48,40.39 ; 43.43,39.49 42.67,38.73 42.67,37.85 41.91,37.08 41.91,27.69 41.78,27.56 41.78,26.42 42.04,26.16 42.04,24.26 41.4,23.62 41.4,23.11 41.78,22.73 42.8,22.73 43.18,22.35 43.18,21.08 43.94,20.32 43.94,19.05 44.58,18.41 44.58,8.38 45.47,7.49 45.47,5.84 46.23,5.08 46.23,3.3 P9.23
GPIO1_28: length 51.6
  TOP w0.121: U5.U18 42.58,40.14 40.24,40.14 40.01,39.91 36.17,39.91 35.31,40.77 31.62,40.77 v1(30.86,40.01)
  LYR4 w0.133: P9.12 32.77,4.45 34.92,6.6 34.92,7.49 34.29,8.13 34.29,13.46 34.8,13.97 34.8,20.7 34.42,21.08 34.42,25.65 31.24,28.83 31.24,39.62 v1(30.86,40.01)
GPIO1_29: length 13.7
  TOP w0.121: U5.V6 52.33,41.39 50.01,43.72 50.01,48.1 51.44,49.53 51.44,51.44 P8.26
GPIO1_30: length 12.2
  TOP w0.121: P8.21 47.12,48.13 47.12,44.85 50.03,41.95 50.03,41.94 50.33,41.64 50.33,40.69 U5.U9
GPIO1_31: length 15.6
  TOP w0.121: U5.V9 49.93,41.69 49.78,41.84 46.86,44.76 46.86,48.01 45.85,49.02 44.32,49.02 44.07,49.28 44.07,51.18 P8.20
GPIO2_1: length 17.9
  TOP w0.121: U5.V12 47.53,41.37 45.09,43.81 42.93,43.81 42.67,44.07 41.15,44.07 40.01,45.21 40.01,48.39 41.27,49.66 41.27,51.44 P8.18
GPIO2_6: length 29.2
  TOP w0.121: 63.82,45.85 v1(63.82,45.09) 63.06,44.32 60.07,44.32 58.1,42.35 58.1,40.01 56.79,38.69 U5.R1
  LYR4 w0.133: P8.45 75.56,49.02 74.8,48.26 72.26,48.26 67.82,43.81 64.14,43.81 63.82,44.13 v1(63.82,45.09)
  BOTTOM w0.121: 63.82,45.85 v1(63.82,45.09)
GPIO2_7: length 29.8
  TOP w0.121: 62.87,45.85 v1(62.87,45.09) 62.36,44.58 59.94,44.58 57.78,42.42 57.78,40.17 56.7,39.09 55.92,39.09 55.53,38.7 U5.R2
  LYR4 w0.133: v1(62.87,45.09) 63.37,45.59 69.22,45.59 72.52,48.9 73.66,48.9 74.3,49.53 74.3,51.44 P8.46
  BOTTOM w0.121: 62.87,45.85 v1(62.87,45.09)
GPIO2_8: length 28.7
  TOP w0.121: v1(61.91,45.09) 61.91,45.85 ; v1(55.13,39.09) U5.R3
  LYR4 w0.133: v1(61.91,45.09) 62.67,45.85 69.09,45.85 71.88,48.64 71.88,50.8 72.39,51.31 72.77,51.31 73.03,51.05 P8.43
  BOTTOM w0.121: v1(55.13,39.09) 55.35,39.09 55.78,39.52 55.78,41.94 57.4,43.56 60.39,43.56 v1(61.91,45.09) 61.91,45.85
GPIO2_9: length 29.1
  TOP w0.121: v1(60.96,45.09) 60.96,45.85 ; v1(54.33,39.09) U5.R4
  LYR4 w0.133: P8.44 71.5,51.18 71.5,48.96 68.64,46.1 61.98,46.1 v1(60.96,45.09)
  BOTTOM w0.121: 60.96,45.85 v1(60.96,45.09) 59.69,43.81 57.28,43.81 55.53,42.07 55.53,39.73 55.3,39.49 54.73,39.49 v1(54.33,39.09)
GPIO2_10: length 29.4
  TOP w0.121: 60.01,45.85 v1(60.01,45.09) 57.47,42.55 57.47,40.29 56.67,39.49 U5.T1
  LYR3 w0.133: v1(60.01,45.09) 60.52,44.58 68.83,44.58 68.96,44.7 68.96,45.97 69.09,46.1 70.48,46.1 70.61,46.23 70.61,46.48 70.48,46.61 69.34,46.61 69.22,46.74 69.22,46.99 69.34,47.12 70.51,47.12 70.61,47.22 70.61,48.03 70.71,48.13 71.14,48.13 71.25,48.24 71.25,48.4 71.14,48.51 70.71,48.51 70.61,48.62 70.61,48.79 70.71,48.9 71.12,48.9 71.25,49.02 71.25,49.4 P8.41
  BOTTOM w0.121: 60.01,45.85 v1(60.01,45.09)
GPIO2_11: length 29.3
  TOP w0.121: 59.05,45.85 v1(59.05,45.09) 57.15,43.18 57.15,40.51 56.53,39.89 55.93,39.89 U5.T2
  LYR3 w0.133: v1(59.05,45.09) 59.82,44.32 69.22,44.32 71.63,46.74 71.63,51.56 P8.42
  BOTTOM w0.121: 59.05,45.85 v1(59.05,45.09)
GPIO2_12: length 29.5
  TOP w0.121: v1(55.13,39.89) U5.T3 ; 58.1,45.85 v1(58.1,45.09)
  LYR3 w0.133: P8.39 69.09,49.02 69.98,49.02 70.1,48.9 70.1,48.64 69.98,48.51 69.22,48.51 69.09,48.39 69.09,48.23 69.19,48.13 70,48.13 70.1,48.03 70.1,47.73 70,47.62 68.81,47.62 68.71,47.52 68.71,44.96 68.58,44.83 65.66,44.83 64.77,45.72 58.74,45.72 v1(58.1,45.09)
  BOTTOM w0.121: v1(55.13,39.89) 55.13,40.31 55.13,42.05 58.1,45.02 v1(58.1,45.09) 58.1,45.85
GPIO2_13: length 29.8
  TOP w0.121: v1(54.33,39.89) U5.T4 ; 57.15,45.85 v1(57.15,45.09)
  LYR3 w0.133: v1(57.15,45.09) 58.04,45.97 64.9,45.97 65.79,45.09 68.2,45.09 68.45,45.34 68.45,48.77 68.2,49.02 67.06,49.02 66.8,49.28 66.8,51.56 P8.40
  BOTTOM w0.121: v1(54.33,39.89) 54.86,40.42 54.86,42.8 v1(57.15,45.09) 57.15,45.85
GPIO2_22: length 29.6
  TOP w0.121: U5.U5 53.53,40.69 53.53,41.72 52.31,42.94 52.31,43.93 v1(52.39,44.01)
  LYR4 w0.133: v1(52.39,44.01) 52.07,43.69 52.07,41.27 52.2,41.15 52.58,41.15 52.7,41.27 52.7,42.29 52.83,42.42 53.21,42.42 53.34,42.29 53.34,41.27 53.47,41.15 55.12,41.15 55.24,41.27 55.24,44.45 55.12,44.58 54.86,44.58 54.74,44.45 54.74,41.78 54.61,41.66 53.98,41.66 53.85,41.78 53.85,45.72 53.72,45.85 52.96,45.85 52.83,45.97 52.83,50.04 P8.27
GPIO2_23: length 29.6
  TOP w0.121: v1(53.53,39.09) U5.R5
  LYR4 w0.121: v1(53.53,39.09) 53.93,39.49 53.93,40.21
  LYR4 w0.133: 55.24,50.16 56.64,48.77 56.64,46.99 56.77,46.86 57.53,46.86 57.66,46.99 57.66,48.64 57.78,48.77 58.42,48.77 58.55,48.64 58.55,40.51 58.42,40.39 58.17,40.39 58.04,40.51 58.04,44.07 57.91,44.2 57.66,44.2 57.53,44.07 57.53,40.51 57.4,40.39 54.1,40.39 53.93,40.21
GPIO2_24: length 29.4
  TOP w0.121: U5.V5 53.13,41.61 51.94,42.8 51.94,43.51 v1(51.45,44.01)
  LYR4 w0.133: P8.28 51.31,51.31 49.66,51.31 49.02,50.67 49.02,41.27 49.15,41.15 49.4,41.15 49.53,41.27 49.53,44.32 49.66,44.45 49.91,44.45 50.04,44.32 50.04,41.27 50.16,41.15 51.56,41.15 51.69,41.27 51.69,43.77 v1(51.45,44.01)
GPIO2_25: length 28.9
  TOP w0.121: v1(52.73,39.09) U5.R6
  LYR4 w0.121: 53.13,40.26 53.13,39.49 v1(52.73,39.09)
  LYR4 w0.133: 53.13,40.26 53.64,40.77 57.02,40.77 57.15,40.89 57.15,44.07 57.02,44.2 56.77,44.2 56.64,44.07 56.64,42.42 56.52,42.29 55.78,42.29 55.65,42.42 55.65,48.64 55.52,48.77 54.86,48.77 54.74,48.64 54.74,46.99 54.61,46.86 53.98,46.86 53.85,46.99 53.85,51.31 55.24,52.7
GPIO3_19: length 30.7
  TOP w0.121: v1(46.33,28.69) U5.C13
  LYR4 w0.133: v1(46.33,28.69) 45.85,28.21 45.85,26.8 45.47,26.42 45.47,23.62 45.85,23.24 45.85,21.84 48.36,19.33 48.36,8.79 51.56,5.59 51.56,3.05 P9.27
GPIO3_21: length 29.4
  TOP w0.121: v1(44.96,22.61) 44.96,26.16 45.93,27.13 U5.A14
  LYR4 w0.133: v1(44.96,22.61) 44.45,22.1 44.45,21.72 45.21,20.95 45.21,20.32 46.35,19.18 46.35,17.53 47.18,16.7 47.18,12 47.37,11.81 47.37,9.27 51.18,5.46 51.18,2.92 P9.25
GRN_C: length 2
  BOTTOM w0.121: P10.10 4.88,32.59 5.21,32.26 R128.2
GRNA: length 33.3
  TOP w0.121: U15.3 25.28,29.07 v1(25.4,28.96)
  LYR3 w0.133: P10.9 3.35,30.94 7.62,26.67 9.4,26.67 11.68,24.38 17.53,24.38 19.56,26.42 20.7,26.42 23.75,29.46 24.89,29.46 v1(25.4,28.96)
HS_IND: length 9.3
  TOP w0.121: TP8.1 25.91,46.74 24.48,48.17 23.28,48.17 22.86,47.75 22.86,45.34 21.95,44.43 U11.16
HUB_BIAS: length 3.3
  TOP w0.121: U11.26 17.91,40.77 17.14,40.01 v1(17.14,39.69)
  BOTTOM w0.121: v1(17.14,39.69) 17.14,39.24 16.95,39.05 R157.1
I2C0_SCL: length 38.2
  TOP w0.121: U2.28 29.07,15.51 v1(29.72,14.86) ; v1(43.93,28.69) U5.C16
  LYR3 w0.133: v1(41.91,20.32) 41.15,19.56 35.18,19.56 30.48,14.86 v1(29.72,14.86)
  BOTTOM w0.121: 29.78,9.27 28.45,9.27 28.19,9.53 28.19,11.43 29.32,12.55 29.32,14.46 v1(29.72,14.86) 30.1,15.24 31.5,15.24 31.75,14.99 R7.2 ; v1(43.93,28.69) 43.43,28.19 43.43,26.92 43.94,26.42 43.94,20.45 43.31,19.81 42.42,19.81 v1(41.91,20.32)
I2C0_SDA: length 32.8
  TOP w0.121: v1(40.51,27.94) 41.4,27.94 42.15,28.69 43.13,28.69 U5.C17 ; U2.27 28.91,15.11 29.34,14.67 29.34,14.53 v1(29.72,14.16)
  LYR3 w0.133: v1(40.51,20.32) 40.01,19.81 35.05,19.81 30.58,15.34 29.57,15.34 29.31,15.09 29.31,14.57 v1(29.72,14.16)
  LYR4 w0.133: v1(40.51,27.94) 40.01,27.43 40.01,20.83 v1(40.51,20.32)
  BOTTOM w0.121: U7.5 29.78,11.3 30.12,11.64 30.12,13.76 v1(29.72,14.16) 30.04,14.48 R4.2
I2C1_SCL: length 33.7
  TOP w0.121: U5.A16 v1(43.93,27.09)
  LYR4 w0.133: v1(38.1,17.27) 38.1,18.16 38.23,18.29 38.73,18.29 38.86,18.16 38.86,3.05 P9.17
  BOTTOM w0.121: v1(38.1,17.27) 39.88,19.05 43.43,19.05 44.32,19.94 44.32,26.7 v1(43.93,27.09)
I2C1_SDA: length 33
  TOP w0.121: U5.B16 v1(43.93,27.89)
  LYR3 w0.133: v1(43.93,27.89) 43.24,28.57 38.73,28.57 v1(37.21,27.05)
  LYR4 w0.133: v1(37.21,27.05) 37.21,27.3 37.34,27.43 37.85,27.43 37.97,27.3 37.97,19.94 39.12,18.8 39.12,7.11 40.01,6.22 P9.18
I2C2_SCL: length 33.8
  TOP w0.121: v1(38.99,27.05) 39.5,27.56 39.5,27.94 40.16,28.6 41.18,28.6 42.06,29.49 43.13,29.49 U5.D17
  LYR4 w0.133: P9.19 43.56,2.92 43.56,6.48 39.62,10.41 39.62,19.3 39.24,19.68 39.24,20.83 38.48,21.59 38.48,26.54 v1(38.99,27.05)
I2C2_SDA: length 33.7
  TOP w0.121: v1(38.99,27.94) 39.12,27.94 40.03,28.85 41.04,28.85 42.08,29.89 U5.D18
  LYR4 w0.133: v1(38.99,27.94) 38.23,27.18 38.23,20.19 39.37,19.05 39.37,7.62 40.89,6.1 41.15,6.1 41.27,6.22 41.27,7.62 41.4,7.75 41.66,7.75 41.78,7.62 41.78,5.21 P9.20
JTAG_EMU0: length 37
  TOP w0.121: v1(56.26,12.06) 56.77,11.56 59.94,11.56 60.38,12 60.38,13.39 60.83,13.84 R176.2 62.17,13.84 v1(62.29,13.97) ; v1(45.53,28.69) U5.C14
  LYR4 w0.133: v1(47.62,14.61) 48.13,15.11 48.13,19.18 45.59,21.72 45.59,23.11 45.21,23.5 45.21,26.54 45.53,26.86 v1(45.53,28.69)
  BOTTOM w0.121: v1(62.29,13.97) 62.29,14.38 62.52,14.61 P7.13 ; v1(56.26,12.06) R170.2 55.12,12.45 54.99,12.57 49.02,12.57 47.62,13.97 v1(47.62,14.61)
JTAG_EMU1: length 42.9
  TOP w0.121: U5.B14 45.53,27.89 45.53,27.11 44.45,26.04 44.45,22.35 v1(44.96,21.84)
  LYR4 w0.133: v1(47.62,16.38) 47.62,17.02 46.99,17.65 46.99,19.94 45.09,21.84 v1(44.96,21.84)
  BOTTOM w0.121: v1(47.62,16.38) 48.26,15.75 48.26,13.72 49.15,12.83 54.99,12.83 55.12,12.95 R171.2 56.9,13.34 59.44,10.79 R179.2 60.45,11.24 60.64,11.43 66.1,11.43 66.87,12.19 66.87,13.72 67.75,14.61 P7.14
JTAG_TCK: length 41.2
  TOP w0.121: U5.A12 47.55,27.47 47.55,26.92 47.3,26.67 45.97,26.67 45.47,26.16 45.47,21.98 47.26,20.19 49.02,20.19 49.21,20.01 49.21,18.02 48.97,17.78 48.39,17.78 47.18,16.57 47.18,11.75 49.18,9.74 49.18,8.85 v1(49.78,8.26)
  LYR3 w0.133: v1(59.63,12.06) 55.31,7.75 50.29,7.75 v1(49.78,8.26)
  BOTTOM w0.121: R180.1 R178.1 v1(59.63,12.06) ; v1(49.78,8.26) 49.66,8.13 R164.2
JTAG_TDI: length 57.4
  TOP w0.121: v1(56.01,6.99) 55.5,6.48 52.32,6.48 49.53,9.27 49.53,9.9 48.13,11.3 48.13,16.89 48.64,17.4 49.08,17.4 49.56,17.87 49.56,17.94 49.56,20.16 49.18,20.54 47.4,20.54 45.85,22.1 45.85,24.38 47.9,26.43 47.9,27.26 47.94,27.3 47.94,27.9 U5.B11
  BOTTOM w0.121: R165.2 v1(56.01,6.99) 57.02,5.97 71.12,5.97 71.37,6.22 71.37,7.49 71.25,7.62 67.18,7.62 66.55,8.26 64.29,8.26
JTAG_TDO: length 40.5
  TOP w0.121: v1(52.7,11.43) 53.14,11.86 53.14,16.08 50.04,19.18 50.04,20.19 49.28,20.95 47.5,20.95 46.2,22.25 46.2,24.23 48.24,26.27 48.24,27.09 48.33,27.18 U5.A11
  BOTTOM w0.121: P7.7 63.18,10.79 62.55,10.16 58.17,10.16 56.9,11.43 v1(52.7,11.43) 52.2,10.92 52.2,8.13 52.7,7.62 54.86,7.62 55.12,7.87 R166.2
JTAG_TMS: length 36
  TOP w0.121: v1(47.93,28.69) U5.C11
  LYR4 w0.133: v1(47.93,28.69) 49.05,27.57 49.05,20.55 51.31,18.29 51.31,16 51.82,15.49 51.82,9.78 v1(52.7,8.89)
  BOTTOM w0.121: v1(52.7,8.89) 54.86,8.89 55.12,9.14 R168.2 55.88,9.53 59.05,6.35 61.98,6.35 62.61,6.99 P7.1
JTAG_TRSTN: length 43.3
  TOP w0.121: v1(52.7,10.16) 53.39,10.85 53.39,16.21 50.29,19.3 50.29,20.32 49.4,21.21 47.62,21.21 46.45,22.39 46.45,24.09 48.51,26.16 48.51,26.96 48.73,27.18 48.73,27.89 U5.B10
  BOTTOM w0.121: P7.2 67.18,6.99 66.55,7.62 62.74,7.62 62.1,6.99 R186.1 61.47,7.37 61.21,7.62 59.05,7.62 55.88,10.79 R169.2 55.12,10.29 54.99,10.16 v1(52.7,10.16)
LDO3: length 9.1
  TOP w0.121: v1(20.57,20.32) 21.84,21.59 26.16,21.59 26.54,21.21 26.54,20.73 26.38,20.57 26.38,19.6 U2.40
  BOTTOM w0.121: R19.1 v1(20.57,20.32)
LDO4: length 2.5
  TOP w0.121: v1(25.2,20.95) U2.43
  BOTTOM w0.121: v1(25.2,20.95) 25.4,21.15 R121.1
LDO_PGOOD: length 13.1
  TOP w0.121: U2.46 v1(24,20.32)
  LYR4 w0.133: v1(30.16,24.77) 29.65,24.26 25.02,24.26 23.88,23.11 23.88,20.83 24,20.7 v1(24,20.32)
  BOTTOM w0.121: v1(30.16,24.77) 30.51,24.77 30.64,24.89 30.64,26.42 30.77,26.54 R141.2
LED2: length 28.7
  TOP w0.121: U15.2 24.78,29.1 v1(24.64,28.96)
  LYR3 w0.133: P10.12 4.88,24.43 6.86,26.42 9.27,26.42 11.56,24.13 17.65,24.13 19.68,26.16 20.83,26.16 23.11,28.45 24.13,28.45 v1(24.64,28.96)
  BOTTOM w0.121: R219.1 5.21,25.1 4.88,24.77 P10.12
LEDAA: length 2.5
  TOP w0.121: R96.2 TP10.1 D2.2
LEDAC: length 34.6
  TOP w0.121: D2.1 2.73,47.75 v1(2.16,47.75) ; Q1.6 33.77,47.51 v1(33.53,47.75)
  BOTTOM w0.121: v1(33.53,47.75) 32.26,49.02 17.4,49.02 16.13,47.75 v1(2.16,47.75)
LEDBA: length 2.5
  TOP w0.121: D3.2 TP11.1 R97.2
LEDBC: length 36.6
  TOP w0.121: D3.1 v1(2.16,46.67) ; Q1.3 32.27,45.2 v1(32.51,44.96)
  BOTTOM w0.121: v1(2.16,46.67) 2.98,47.5 16.26,47.5 17.53,48.77 29.97,48.77 31.37,47.37 31.37,46.61 30.86,46.1 30.86,45.47 31.37,44.96 v1(32.51,44.96)
LEDCA: length 2.5
  TOP w0.121: D4.2 TP12.1 R98.2
LEDCC: length 31.2
  TOP w0.121: v1(29.72,47.75) 29.96,47.51 Q2.6 ; D4.1 v1(2.16,45.09)
  BOTTOM w0.121: v1(2.16,45.09) 4.32,47.24 16.38,47.24 17.65,48.51 28.96,48.51 v1(29.72,47.75)
LEDDA: length 2.5
  TOP w0.121: R99.2 TP13.1 D5.2
LEDDC: length 33.3
  TOP w0.121: v1(28.7,44.96) 28.46,45.2 Q2.3 ; D5.1 v1(2.16,43.5)
  BOTTOM w0.121: v1(28.7,44.96) 27.56,44.96 27.16,45.36 27.16,47.9 26.8,48.26 17.78,48.26 16.51,46.99 5.65,46.99 v1(2.16,43.5)
MDIO_CLK: length 16.8
  TOP w0.121: v1(36.45,36.83) 36.96,37.34 39.24,37.34 39.62,36.96 41.27,36.96 42.04,36.2 42.63,36.2 U5.M18 ; v1(28.45,35.81) 27.79,35.15 U15.17
  BOTTOM w0.121: v1(28.45,35.81) 29.21,36.58 32.13,36.58 32.64,37.08 36.2,37.08 v1(36.45,36.83)
MDIO_DATA: length 20.1
  TOP w0.121: v1(37.21,36.83) 37.72,36.32 38.48,36.32 38.86,36.7 41.02,36.7 41.83,35.89 43.13,35.89 U5.M17 ; U15.16 28.8,34.14 28.96,34.29 28.96,35.43 v1(29.34,35.81)
  BOTTOM w0.121: v1(37.21,36.83) 36.7,36.32 36.07,36.32 35.56,36.83 32.89,36.83 32.38,36.32 29.84,36.32 v1(29.34,35.81) 28.13,34.61 R131.2
MMC0_CLKO: length 73.5
  TOP w0.121: R192.2 v1(80.52,34.54) ; U5.G17 43.13,32.69 42.34,32.69 41.4,31.75 40.39,31.75 39.62,30.99 38.86,30.99 36.45,28.57 36.45,22.99 v1(37.21,22.23)
  LYR3 w0.133: v1(37.21,22.23) 37.87,21.57 39.48,21.57 41.78,23.88 55.63,23.88 56.64,22.86 60.58,22.86 61.09,22.35 71.25,22.35 74.3,25.4 78.11,25.4 81.53,28.83 81.53,33.53 v1(80.52,34.54)
  BOTTOM w0.121: v1(80.52,34.54) R192.2 81.6,34.22 P4.5
MMC0_CMD: length 73.4
  TOP w0.121: R191.2 v1(80.52,31.75) ; U5.G18 42.32,32.29 40.77,30.73 40.04,30.73 39.02,29.72 38.35,29.72 36.7,28.07 36.7,23.5 v1(37.21,22.99)
  LYR3 w0.133: v1(80.52,31.75) 81.28,30.99 81.28,29.08 77.85,25.65 74.17,25.65 71.12,22.61 61.21,22.61 60.71,23.11 57.15,23.11 57.02,23.24 57.02,23.5 57.15,23.62 59.56,23.62 59.69,23.75 59.69,24 59.56,24.13 41.66,24.13 39.34,21.82 38.38,21.82 v1(37.21,22.99)
  BOTTOM w0.121: v1(80.52,31.75) R191.2 81.55,32.02 P4.3
MMC0_DAT0: length 73.4
  TOP w0.121: R193.2 v1(80.52,36.58) ; v1(43.93,31.89) U5.G16
  LYR3 w0.133: v1(41.91,23.24) 42.29,23.62 55.37,23.62 55.5,23.5 55.5,23.24 55.37,23.11 51.69,23.11 51.56,22.99 51.56,22.73 51.69,22.61 60.45,22.61 60.96,22.1 71.37,22.1 74.42,25.15 78.36,25.15 81.79,28.57 81.79,35.31 v1(80.52,36.58)
  LYR4 w0.133: v1(41.91,23.24) 42.42,23.75 42.42,26.16 42.04,26.54 42.04,27.3 42.55,27.81 42.55,30.71 43.22,31.38 43.73,31.89 v1(43.93,31.89)
  BOTTOM w0.121: P4.7 82.36,36.58 v1(80.52,36.58)
MMC0_DAT1: length 73.4
  TOP w0.121: R194.2 v1(80.52,37.59) ; v1(44.73,31.89) U5.G15
  LYR3 w0.133: v1(80.52,37.59) 82.04,36.07 82.04,28.32 78.61,24.89 74.55,24.89 71.5,21.84 60.83,21.84 60.33,22.35 47.61,22.35 47.5,22.46 47.5,22.62 47.61,22.73 50.93,22.73 51.05,22.86 51.05,23.09 50.93,23.22 v1(42.67,23.22)
  LYR4 w0.121: 43.55,31.27 43.76,31.49 44.33,31.49 v1(44.73,31.89)
  LYR4 w0.133: v1(42.67,23.22) 42.67,26.29 42.29,26.67 42.29,27.18 42.8,27.69 42.8,30.52 43.55,31.27
  BOTTOM w0.121: P4.8 82.44,37.59 v1(80.52,37.59)
MMC0_DAT2: length 72.5
  TOP w0.121: U5.F18 41.89,31.49 40.88,30.48 40.13,30.48 39.12,29.46 38.73,29.46 37.72,28.45 37.72,23.5 v1(38.99,22.23) ; R190.2 v1(80.52,29.72)
  LYR3 w0.133: v1(80.52,29.72) 80.52,29.34 77.34,26.16 73.91,26.16 70.87,23.11 61.85,23.11 61.72,23.24 61.72,24.89 61.59,25.02 58.42,25.02 58.29,25.15 58.29,25.4 58.42,25.53 61.59,25.53 61.72,25.65 61.72,25.91 61.59,26.04 54.23,26.04 52.83,24.64 39.88,24.64 38.48,23.24 38.48,22.73 v1(38.99,22.23)
  BOTTOM w0.121: P4.1 82.41,29.72 v1(80.52,29.72)
MMC0_DAT3: length 72.4
  TOP w0.121: R195.2 v1(80.52,30.73) ; v1(38.99,22.99) 37.97,24 37.97,28.32 38.86,29.21 39.24,29.21 40.25,30.22 41.01,30.22 41.88,31.09 43.13,31.09 U5.F17
  LYR3 w0.133: v1(80.52,30.73) 81.03,30.23 81.03,29.34 77.6,25.91 74.04,25.91 70.99,22.86 61.47,22.86 61.34,22.99 61.34,24.38 61.21,24.51 54.36,24.51 54.23,24.64 54.23,24.89 54.36,25.02 57.78,25.02 57.91,25.15 57.91,25.4 57.78,25.53 54.23,25.53 53.09,24.38 40.39,24.38 v1(38.99,22.99)
  BOTTOM w0.121: P4.2 82.33,30.73 v1(80.52,30.73)
Net_63: length 0.6
  TOP w0.121: v1(46.33,39.89) 46.73,39.49
Net_129: length 0.6
  TOP w0.121: 69.53,36.69 v1(69.13,37.09)
Net_130: length 0.6
  TOP w0.121: 69.53,39.89 v1(69.13,40.29)
Net_131: length 0.6
  TOP w0.121: 70.33,28.69 v1(69.93,28.29)
Net_132: length 0.6
  TOP w0.121: 73.53,28.69 v1(73.93,28.29)
Net_267: length 0.6
  TOP w0.121: v1(54.33,32.69) 53.93,33.09
Net_270: length 0.6
  TOP w0.121: v1(45.53,39.09) 45.93,38.69
NINT/RXCLK/PHYAD1: length 3
  BOTTOM w0.121: v1(23.11,29.53) 22.16,28.57 21.46,28.57 21.46,27.62
NON_REM1: length 3.6
  TOP w0.121: 25.53,41.91 24.38,41.91 24,42.29 23.37,42.29 U11.13 ; 25.53,41.91 R154.2 ; 25.53,41.91 R158.1
NON_REM2: length 6.3
  TOP w0.121: TP7.1 19.68,45.85 20.45,45.08 U11.19
OSC0_IN: length 13.3
  TOP w0.121: U5.V10 49.13,41.79 46.6,44.32 43.95,44.32 v1(43.69,44.58) 43.18,45.09 43.18,45.85 44.45,45.85
  BOTTOM w0.121: Y2.3 45.3,45.55 Y3.3 43.69,45.51 v1(43.69,44.58)
OSC0_OUT: length 10.6
  TOP w0.121: 41.91,45.85 41.91,45.21 43.05,44.07 46.5,44.07 48.73,41.84 48.73,40.69 U5.U11
OSC0_OUT1: length 7.3
  TOP w0.121: R21.2 R24.1 ; R24.1 41.91,47.62 v1(41.4,48.13) ; R24.1 C27.1
  BOTTOM w0.121: Y2.1 39.79,47.16 Y3.1 41.4,47.2 v1(41.4,48.13)
OSC1_IN: length 11
  TOP w0.121: U5.A6 52.67,27.15 52.67,25.82 52.96,25.53 52.96,21.97 54.36,20.57 54.99,20.57 v1(55.24,20.32) 55.24,19.59 Y1.1
  BOTTOM w0.121: C23.2 v1(55.24,20.32)
OSC1_OUT: length 4
  TOP w0.121: R22.2 53.85,23.81 53.85,24.6 53.82,24.63 53.82,25.54 54.08,25.8 54.08,26.94 53.93,27.1 U5.A4
OSC1_OUT1: length 7.3
  TOP w0.121: R22.1 53.98,22.23 54.86,21.34 56.2,21.34 56.96,20.57 57.53,20.57 v1(57.78,20.32) 57.78,19.59 Y1.2
  BOTTOM w0.121: C24.2 v1(57.78,20.32)
P_BYPASS: length 3.4
  TOP w0.121: U2.47 23.6,20.09 23.37,20.32 v1(22.73,20.32)
  BOTTOM w0.121: C5.2 22.73,21.27 v1(22.73,20.32)
P_INT_LDO: length 4.4
  TOP w0.121: v1(22.1,20.83) 22.1,20.19 22.71,19.58 U2.48
  BOTTOM w0.121: v1(22.1,20.83) 21.34,20.83 20.19,21.97 C4.2
P_L1: length 1
  TOP w0.203: U2.20 26,12.45
P_L2: length 0.6
  TOP w0.203: 27.2,12.8 U2.23
P_L3: length 1.1
  TOP w0.203: 29.01,16.71 29.21,16.51 ; 29.01,16.71 U2.31 ; 29.01,16.71 29.26,16.71
P_MUXIN: length 6.6
  TOP w0.121: v1(23.11,12.45) 23.22,12.45 23.6,12.83 U2.14
  BOTTOM w0.121: v1(23.11,12.45) 22.35,11.68 22.35,9.53 22.48,9.4 R1.2 R2.1
P_MUXOUT: length 12.6
  TOP w0.121: U2.16 24.4,12.84 24,12.45 v1(23.88,12.45)
  LYR4 w0.133: v1(27.69,20.95) 27.69,16.26 v1(23.88,12.45)
  BOTTOM w0.121: R8.2 27.3,21.34 v1(27.69,20.95)
P_WAKEUP: length 3.4
  TOP w0.121: U2.13 22.83,13.44 22.35,12.95 v1(22.35,12.45)
  BOTTOM w0.121: v1(22.35,12.45) 22.83,12.92 23.27,12.92 R11.1
PDDR_A0: length 7.1
  TOP w0.121: U5.F3 v1(55.13,31.09)
  BOTTOM w0.121: v1(55.13,31.09) 55.28,31.24 56.52,31.24 56.75,31.01 56.75,28.83 56.88,28.7 57.57,28.7 57.89,28.38 58.55,28.38 58.67,28.51 58.67,28.77 R29.2
PDDR_A1: length 6.5
  TOP w0.121: U5.H1 57.15,33.09 57.35,32.89 58.6,32.89 58.67,32.82 58.67,32.71 58.6,32.64 57.73,32.64 57.66,32.56 57.66,32.46 57.97,32.15 58.83,32.15 59.04,32.15 59.44,31.75 R25.2
PDDR_A2: length 8
  TOP w0.121: U5.E4 v1(54.33,30.29)
  BOTTOM w0.121: R30.2 57.91,26.04 57.47,26.48 57.47,27.5 57.09,27.88 56.2,27.88 56.01,28.07 56.01,29.46 55.63,29.84 54.78,29.84 v1(54.33,30.29)
PDDR_A3: length 7.2
  TOP w0.121: v1(55.13,28.69) U5.C3
  BOTTOM w0.121: v1(55.13,28.69) 55.13,28.3 55.03,28.19 54.84,28.19 54.74,28.09 54.74,27.3 54.84,27.2 55.02,27.2 55.12,27.3 55.12,27.71 55.22,27.81 55.4,27.81 55.5,27.71 55.5,27.3 55.6,27.2 56.73,27.2 56.83,27.1 R26.2
PDDR_A4: length 7.2
  TOP w0.121: U5.C2 55.93,28.69 56.65,28.69 58.18,27.16 58.18,24.68 58.74,24.13 R31.2
PDDR_A5: length 7.1
  TOP w0.121: R32.2 57.78,24.23 57.94,24.38 57.94,26.13 57.78,26.28 57.26,26.28 57.15,26.4 57.15,26.56 57.26,26.67 57.78,26.67 57.91,26.8 57.91,27.05 57.78,27.18 57.27,27.18 57.14,27.3 57.14,27.85 56.7,28.29 U5.B1
PDDR_A6: length 6.6
  TOP w0.121: v1(53.53,29.49) U5.D5
  BOTTOM w0.121: R33.2 54.99,25.34 54.99,26.43 54.88,26.54 54.72,26.54 54.61,26.43 54.61,26.15 54.5,26.04 54.34,26.04 54.23,26.15 54.23,28.13 53.93,28.43 53.93,28.65 53.93,29.09 v1(53.53,29.49)
PDDR_A7: length 7.4
  TOP w0.121: U5.E2 55.93,30.29 56.58,30.29 59.19,27.68 59.19,26.28 59.44,26.04 R34.2
PDDR_A8: length 8.2
  TOP w0.121: v1(54.33,29.49) U5.D4
  BOTTOM w0.121: v1(54.33,29.49) 55.35,29.49 55.75,29.08 55.75,27.81 56.01,27.56 57.02,27.56 57.15,27.43 57.15,26.04 58.1,25.08 R35.2
PDDR_A9: length 8
  TOP w0.121: U5.C1 56.63,29.09 58.43,27.29 58.43,27.06 58.43,27.06 58.43,25.01 59.37,24.07 59.37,23.37 59.56,23.18 R36.2
PDDR_A10: length 7.1
  TOP w0.121: U5.F4 v1(54.33,31.09)
  BOTTOM w0.121: R37.2 58.42,27.81 57.91,27.81 57.35,28.37 56.72,28.37 56.5,28.59 56.5,28.86 56.5,30.11 55.92,30.69 54.73,30.69 v1(54.33,31.09)
PDDR_A11: length 6.4
  TOP w0.121: R38.2 59.69,27.94 57.27,30.36 57.27,30.97 57.15,31.09 55.93,31.09 U5.F2
PDDR_A12: length 7.3
  TOP w0.121: v1(55.13,30.29) U5.E3
  BOTTOM w0.121: v1(55.13,30.29) 55.69,30.29 56.25,29.72 56.25,28.96 56.25,28.32 56.45,28.12 57.22,28.12 57.78,27.56 57.78,26.67 57.91,26.54 58.45,26.54 58.55,26.64 R39.2
PDDR_A13: length 7.8
  TOP w0.121: U5.H3 v1(55.13,32.69)
  BOTTOM w0.121: R40.2 57.66,31.75 57.4,32 55.61,32 55.5,32.12 55.5,32.27 55.61,32.38 56.9,32.38 57.02,32.51 57.02,32.72 56.9,32.84 55.28,32.84 v1(55.13,32.69)
PDDR_BA0: length 7
  TOP w0.121: U5.C4 v1(54.33,28.69)
  BOTTOM w0.121: v1(54.33,28.69) 54.48,28.54 54.48,27.05 54.6,26.92 55.12,26.92 55.24,26.8 55.24,25.88 55.35,25.78 55.5,25.78 55.6,25.88 55.6,26.57 55.7,26.67 55.89,26.67 56.01,26.55 56.01,25.4 R41.2
PDDR_BA1: length 7.3
  TOP w0.121: U5.E1 56.48,30.84 56.91,30.84 57.02,30.73 57.02,30.26 57.02,30.26 57.02,30.23 59.44,27.81 59.44,26.67 59.56,26.54 60.25,26.54 60.33,26.62 60.33,26.8 R42.2
PDDR_BA2: length 6.8
  TOP w0.121: U5.B3 55.13,27.89 55.13,27.32 54.86,27.05 54.86,26.9 54.97,26.8 55.39,26.8 55.5,26.69 55.5,26.53 55.39,26.42 54.98,26.42 54.86,26.3 54.86,26.16 54.99,26.04 55.75,26.04 55.88,25.91 R43.2
PDDR_CASN: length 6.7
  TOP w0.121: R64.2 60.33,28.7 60.33,28.52 60.25,28.45 59.53,28.45 59.04,28.94 59.04,29.86 58.96,29.94 58.04,29.94 57.52,30.46 57.52,31.13 57.16,31.49 U5.F1
PDDR_CKE: length 7.8
  TOP w0.121: U5.G3 v1(55.13,31.89)
  BOTTOM w0.121: R62.2 57.79,30.8 57.66,30.67 57.66,29.33 57.55,29.21 57.39,29.21 57.27,29.33 57.27,31.5 57.02,31.75 55.27,31.75 v1(55.13,31.89)
PDDR_CLK: length 8.3
  TOP w0.095: R60.2 59.95,24.31 59.63,24.31 58.67,25.27 58.67,27.43 56.62,29.49 55.93,29.49 U5.D2
PDDR_CLKN: length 8.2
  TOP w0.095: R61.2 60.45,24.77 60.45,24.67 60.38,24.59 59.75,24.59 58.95,25.39 58.95,27.55 56.61,29.89 U5.D1
PDDR_CSN: length 6.9
  TOP w0.121: U5.H2 55.93,32.69 57.08,32.69 57.87,31.9 58.94,31.9 59.56,31.27 59.56,30.48 59.69,30.35 60.25,30.35 60.33,30.43 60.33,30.61 R63.2
PDDR_D0: length 6.4
  TOP w0.121: v1(55.13,36.69) U5.M3
  BOTTOM w0.121: R44.2 58.67,36.64 58.67,36.9 58.55,37.02 57.79,37.02 57.66,37.15 57.66,38.09 57.4,38.35 57.12,38.35 55.46,36.69 v1(55.13,36.69)
PDDR_D1: length 7.5
  TOP w0.121: v1(54.33,36.69) U5.M4
  BOTTOM w0.121: R45.2 58.04,37.47 57.91,37.59 57.91,38.19 57.66,38.44 57.66,39.01 57.43,39.24 57.27,39.24 57.14,39.12 57.14,38.73 55.51,37.09 54.73,37.09 v1(54.33,36.69)
PDDR_D2: length 6.7
  TOP w0.121: R46.2 59.82,40.64 59.44,40.64 59.18,40.39 59.18,38.86 58.93,38.61 58.29,38.61 57.78,38.1 57.78,37.34 57.54,37.09 U5.N1
PDDR_D3: length 7.4
  TOP w0.121: R47.2 59.31,41.27 58.93,40.89 58.93,39.12 58.67,38.86 58.13,38.86 56.77,37.49 55.93,37.49 U5.N2
PDDR_D4: length 7.8
  TOP w0.121: U5.N3 v1(55.13,37.49)
  BOTTOM w0.121: v1(55.13,37.49) 55.52,37.49 56.9,38.86 56.9,40.39 57.02,40.51 57.28,40.51 57.4,40.39 57.4,39.62 57.91,39.12 57.91,38.54 58.04,38.42 R48.2
PDDR_D5: length 8.2
  TOP w0.121: U5.N4 v1(54.33,37.49)
  BOTTOM w0.121: R49.2 58.04,39.37 57.66,39.75 57.66,40.64 57.53,40.77 56.77,40.77 56.64,40.64 56.64,38.99 55.54,37.89 54.73,37.89 v1(54.33,37.49)
PDDR_D6: length 6.6
  TOP w0.121: U5.P3 v1(55.13,38.29)
  BOTTOM w0.121: R50.2 58.04,40.32 57.91,40.45 57.91,40.89 57.78,41.02 56.61,41.02 56.39,40.8 56.39,39.12 55.56,38.29 v1(55.13,38.29)
PDDR_D7: length 7
  TOP w0.121: U5.P4 v1(54.33,38.29)
  BOTTOM w0.121: R51.2 56.52,41.27 56.13,40.89 56.13,39.24 55.58,38.69 54.73,38.69 v1(54.33,38.29)
PDDR_D8: length 6.9
  TOP w0.121: R52.2 60.33,33.46 60.33,33.25 60.25,33.18 59.73,33.18 59.6,33.05 59.6,32.59 59.52,32.51 59.38,32.51 59.18,32.71 59.18,33.32 59.11,33.39 57.73,33.39 57.66,33.47 57.66,34.09 57.58,34.16 57.35,34.16 57.28,34.09 57.28,33.81 57.2,33.74 56.48,33.74 U5.J1
PDDR_D9: length 6.6
  TOP w0.121: U5.K1 56.44,34.8 57.07,34.8 57.15,34.72 57.15,34.49 57.23,34.42 57.45,34.42 57.53,34.49 57.53,34.72 57.61,34.8 57.83,34.8 57.91,34.72 57.91,33.73 57.98,33.66 59.49,33.66 59.56,33.73 59.56,34.05 59.64,34.13 60.25,34.13 60.33,34.21 60.33,34.42 R53.2
PDDR_D10: length 7.3
  TOP w0.121: R54.2 59.64,35.56 59.56,35.48 59.56,34.4 59.32,34.16 59.32,33.99 59.24,33.91 58.24,33.91 58.17,33.99 58.17,35.01 58.09,35.09 55.93,35.09 U5.K2
PDDR_D11: length 7.2
  TOP w0.121: v1(55.13,35.09) U5.K3
  BOTTOM w0.121: R55.2 58.1,32.7 57.28,33.53 57.28,35.78 56.86,36.2 56.52,36.2 55.41,35.09 v1(55.13,35.09)
PDDR_D12: length 7.8
  TOP w0.121: U5.K4 v1(54.33,35.09)
  BOTTOM w0.121: v1(54.33,35.09) 54.73,35.49 55.45,35.49 56.53,36.58 56.83,36.58 57.54,35.87 57.54,33.91 57.79,33.66 R56.2
PDDR_D13: length 7.6
  TOP w0.121: v1(55.13,35.89) U5.L3
  BOTTOM w0.121: R57.2 58.67,34.48 58.67,34.29 58.55,34.16 57.91,34.16 57.78,34.29 57.78,35.97 57.12,36.63 57.12,37.08 57,37.21 56.77,37.21 55.45,35.89 v1(55.13,35.89)
PDDR_D14: length 7.5
  TOP w0.121: U5.L4 v1(54.33,35.89)
  BOTTOM w0.121: v1(54.33,35.89) 54.73,36.29 55.41,36.29 56.96,37.85 57.25,37.85 57.37,37.72 57.37,36.73 58.04,36.07 58.55,36.07 58.67,35.94 58.67,35.69 R58.2
PDDR_D15: length 7.2
  TOP w0.121: R59.2 60.13,38.02 60.06,37.94 58.52,37.94 58.42,37.84 58.42,35.92 58.34,35.83 58,35.83 57.91,35.92 57.91,36.22 57.81,36.32 57.51,36.32 57.4,36.22 57.4,35.96 57.28,35.83 57.02,35.83 56.57,36.29 U5.M1
PDDR_DQM0: length 7
  TOP w0.121: R67.2 60.01,39.5 59.56,39.5 59.44,39.37 59.44,38.61 59.18,38.35 58.42,38.35 58.03,37.97 58.03,36.94 57.78,36.69 55.93,36.69 U5.M2
PDDR_DQM1: length 6.4
  TOP w0.121: R70.2 60.33,32.51 60.33,32.3 60.25,32.23 59.31,32.23 58.93,32.61 58.93,33.07 58.85,33.15 57.48,33.15 57.4,33.22 57.4,33.41 57.33,33.49 55.93,33.49 U5.J2
PDDR_DQS0: length 7.1
  TOP w0.121: R68.2 58.96,42.23 58.67,41.94 58.67,39.37 58.41,39.1 58,39.1 56.78,37.89 U5.P1
PDDR_DQS1: length 7
  TOP w0.121: R71.2 59.39,36.51 59.31,36.44 59.31,34.5 58.97,34.16 58.49,34.16 58.41,34.24 58.41,34.91 58.41,34.91 58.41,35.12 58.41,35.21 58.29,35.34 56.48,35.34 U5.L1
PDDR_DQSN0: length 8.1
  TOP w0.121: R69.2 59.56,43.18 58.42,42.04 58.42,39.88 56.83,38.29 55.93,38.29 U5.P2
PDDR_DQSN1: length 7.7
  TOP w0.121: R72.2 59.69,37.47 59.56,37.34 59.56,36.96 59.44,36.83 59.28,36.83 59.18,36.93 59.18,37.36 59.08,37.47 58.9,37.47 58.8,37.36 58.8,35.69 58.7,35.58 56.82,35.58 56.52,35.89 55.93,35.89 U5.L2
PDDR_ODT: length 6.7
  TOP w0.121: U5.G1 57.13,32.29 57.77,31.65 58.83,31.65 59.31,31.18 59.31,29.5 59.44,29.37 60.25,29.37 60.33,29.44 60.33,29.65 R73.2
PDDR_RASN: length 8
  TOP w0.121: U5.G4 v1(54.33,31.89)
  BOTTOM w0.121: R65.2 58.04,29.84 57.91,29.72 57.91,29.08 57.78,28.96 57.15,28.96 57.02,29.08 57.02,31.24 56.77,31.49 54.73,31.49 v1(54.33,31.89)
PDDR_WEN: length 6.6
  TOP w0.121: R66.2 56.83,23.81 57.69,24.67 57.69,25.91 57.56,26.04 57.02,26.04 56.9,26.16 56.9,27.64 56.64,27.89 55.93,27.89 U5.B2
PHY_VDDCR: length 4.3
  TOP w0.254: v1(27.18,28.96) 27.16,28.96 26.79,29.33 U15.6
  BOTTOM w0.381: v1(27.18,28.96) 28.07,29.84 C124.1 28.13,30.54 C125.1
PHY_XTAL1: length 6.9
  TOP w0.121: Y4.1 26.29,26.54 v1(26.29,27.81)
  BOTTOM w0.121: v1(26.29,27.81) 26.29,26.61 C132.1 ; C132.1 26.7,26.54 26.83,26.42 26.83,25.65 26.96,25.53 R199.1 ; C132.1 26,26.54 25.88,26.42 25.88,25.65 25.75,25.53 R140.2
PHY_XTAL2: length 4.8
  TOP w0.121: v1(25.4,27.81) 25.4,28.32 25.85,28.77 25.85,29.14 25.78,29.21 U15.4
  BOTTOM w0.121: R144.1 R140.1 v1(25.4,27.81)
PHYX: length 5.1
  TOP w0.121: Y4.2 23.18,26.48 v1(23.18,27.81)
  BOTTOM w0.121: v1(23.18,27.81) C131.1 23.5,26.54 23.62,26.42 23.62,25.65 23.75,25.53 R144.2
PLLFILT: length 2.6
  TOP w0.121: U11.25 17.91,41.27 16.95,40.32 C145.1
PMIC_INT: length 17.8
  TOP w0.121: v1(40.51,27.05) 41.02,27.05 42.26,28.29 U5.B18
  LYR3 w0.133: v1(40.51,27.05) 40.26,27.05 39.12,25.91 38.61,25.91 38.1,25.4 35.81,25.4 35.18,24.77 v1(34.92,24.77) 34.29,25.4 30.1,25.4 29.72,25.02 29.72,24.32 v1(29.21,23.81)
  BOTTOM w0.121: R28.2 v1(34.92,24.77) ; v1(29.21,23.81) R10.2
PMIC_INT_PU: length 4.6
  TOP w0.121: U14.7 33.66,26.28 33.53,26.41 33.53,27.59 33.66,27.72 34.51,27.72 v1(34.92,27.3)
  BOTTOM w0.121: R28.1 v1(34.92,27.3)

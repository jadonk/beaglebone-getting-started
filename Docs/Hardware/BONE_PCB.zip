# Allegro board BeagleBone_revC1_ALLEGRO.brd (continued)
## Nets (continued)
GPIO1_31: P8.20(35) U5.V9(GPMC_CSN2/GPMC_BE1N/MMC1_CMD/PR)
GPIO2_1: P8.18(34) U5.V12(GPMC_CLK/LCD_MEM_CLK/GPMC_WAIT1)
GPIO2_6: P8.45(23) R80.2 R100.1 U5.R1(LCD_DATA0/GPMC_A0//EHRPWM2A//PR)
GPIO2_7: P8.46(48) R81.2 R101.1 U5.R2(LCD_DATA1/GPMC_A1//EHRPWM2B//PR)
GPIO2_8: P8.43(22) R82.2 R102.1 U5.R3(LCD_DATA2/GPMC_A2//EHRPWM2_TRIP)
GPIO2_9: P8.44(47) R83.2 R103.1 U5.R4(LCD_DATA3/GPMC_A3//EHRPWM2_SYNC)
GPIO2_10: P8.41(21) R84.2 R104.1 U5.T1(LCD_DATA4/GPMC_A4//EQEP2A_IN//P)
GPIO2_11: P8.42(46) R85.2 R105.1 U5.T2(LCD_DATA5/GPMC_A5//EQEP2B_IN//P)
GPIO2_12: P8.39(20) R86.2 R106.1 U5.T3(LCD_DATA6/GPMC_A6/PR1_EDIO_DATA)
GPIO2_13: P8.40(45) R87.2 R107.1 U5.T4(LCD_DATA7/GPMC_A7/PR1_EDIO_DATA)
GPIO2_22: P8.27(14) U5.U5(LCD_VSYNC/GPMC_A8//PR1_EDIO_DAT)
GPIO2_23: P8.29(15) U5.R5(LCD_HSYNC/GPMC_A9//PR1_EDIO_DAT)
GPIO2_24: P8.28(39) U5.V5(LCD_PCLK/GPMC_A10//PR1_EDIO_DAT)
GPIO2_25: P8.30(40) U5.R6(LCD_AC_BIAS_EN/GPMC_A11//PR1_ED)
GPIO3_19: P9.27(14) U5.C13(MCASP0_FSR/EQEP0B_IN/MCASP0_AXR)
GPIO3_21: P9.25(13) U5.A14(MCASP0_AHCLKX/EQEP0_STROBE/MCAS)
GRN_C: P10.10(GRNC) R128.2
GRNA: P10.9(GRNA) U15.3(LED1/REGOFF)
HS_IND: TP8.1(TP) U11.16(HS_IND)
HUB_BIAS: R157.1 U11.26(RBIAS)
I2C0_SCL: R7.2 U2.28(SCL) U5.C16(I2C0_SCL/TIMER7/UART2_RTSN/ECAP) U7.6(SCL)
I2C0_SDA: R4.2 U2.27(SDA) U5.C17(I2C0_SDA/TIMER4/UART2_CTSN/ECAP) U7.5(SDA)
I2C1_SCL: P9.17(9) U5.A16(SPI0_CS0/MMC2_SDWP/I2C1_SCL/EHR)
I2C1_SDA: P9.18(34) U5.B16(SPI0_D1/MMC1_SDWP/I2C1_SDA/EHRP)
I2C2_SCL: P9.19(10) U5.D17(UART1_RTSN/TIMER5/DCAN0_RX/I2C2)
I2C2_SDA: P9.20(35) U5.D18(UART1_CTSN/TIMER6/DCAN0_TX/I2C2)
JTAG_EMU0: P7.13(EMU0) R170.2 R176.2 U5.C14(EMU0/GPIO3_7)
JTAG_EMU1: P7.14(EMU1) R171.2 R179.2 U5.B14(EMU1/GPIO3_8)
JTAG_TCK: R164.2 R178.1 R180.1 U5.A12(TCK)
JTAG_TDI: P7.3(TDI) R165.2 U5.B11(TDI)
JTAG_TDO: P7.7(TDO) R166.2 U5.A11(TDO)
JTAG_TMS: P7.1(TMS) R168.2 U5.C11(TMS)
JTAG_TRSTN: P7.2(TRSTN) R169.2 R186.1 U5.B10(NTRST)
LDO3: R19.1 U2.40(LDO3)
LDO4: R121.1 U2.43(LDO4)
LDO_PGOOD: R141.2 U2.46(LDO_PGOOD)
LED2: P10.12(YELA) R219.1 U15.2(LED2/NINTSEL)
LEDAA: D2.2(A) R96.2 TP10.1(TP)
LEDAC: D2.1(C) Q1.6(3)
LEDBA: D3.2(A) R97.2 TP11.1(TP)
LEDBC: D3.1(C) Q1.3
LEDCA: D4.2(A) R98.2 TP12.1(TP)
LEDCC: D4.1(C) Q2.6(3)
LEDDA: D5.2(A) R99.2 TP13.1(TP)
LEDDC: D5.1(C) Q2.3
MDIO_CLK: U5.M18(MDIO_CLK/TIMER5/UART5_TXD/UART3) U15.17(MDC)
MDIO_DATA: R131.2 U5.M17(MDIO_DATA/TIMER6/UART5_RXD/UART) U15.16(MDIO)
MMC0_CLKO: P4.5(CLOCK) R192.2 U5.G17(MMC0_CLK/GPMC_A24/UART3_CTSN/UA)
MMC0_CMD: P4.3(CMD) R191.2 U5.G18(MMC0_CMD/GPMC_A25/UART3_RTSN/UA)
MMC0_DAT0: P4.7(DAT0) R193.2 U5.G16(MMC0_DAT0/GPMC_A23/UART5_RTSN/U)
MMC0_DAT1: P4.8(DAT1) R194.2 U5.G15(MMC0_DAT1/GPMC_A22/UART5_CTSN/U)
MMC0_DAT2: P4.1(DAT2) R190.2 U5.F18(MMC0_DAT2/GPMC_A21/UART4_RTSN/T)
MMC0_DAT3: P4.2(CD/DAT3) R195.2 U5.F17(MMC0_DAT3/GPMC_A20/UART4_CTSN/T)
NINT/RXCLK/PHYAD1: R215.1 R216.1
NON_REM1: R154.2 R158.1 U11.13(NON_REM1)
NON_REM2: R155.2 R159.1 TP7.1(TP) U11.19(SUSP_IND/NON_REM0)
OSC0_IN: C26.1 R21.1 U5.V10(OSC0_IN) Y2.3 Y3.3
OSC0_OUT: R24.2 U5.U11(OSC0_OUT)
OSC0_OUT1: C27.1 R21.2 R24.1 Y2.1 Y3.1
OSC1_IN: C23.2 U5.A6(OSC1_IN) Y1.1
OSC1_OUT: R22.2 U5.A4(OSC1_OUT)
OSC1_OUT1: C24.2 R22.1 Y1.2
P_BYPASS: C5.2 U2.47(BYPASS)
P_INT_LDO: C4.2 U2.48(INT_LDO)
P_L1: L1.1 U2.20(L1)
P_L2: L2.1 U2.23(L2)
P_L3: L3.1 U2.31(L3)
P_MUXIN: R1.2 R2.1 U2.14(MUX_IN)
P_MUXOUT: R8.2 U2.16(MUX_OUT)
P_WAKEUP: R11.1 U2.13(WAKEUP)
PDDR_A0: R29.2 U5.F3(DDR_A0)
PDDR_A1: R25.2 U5.H1(DDR_A1)
PDDR_A2: R30.2 U5.E4(DDR_A2)
PDDR_A3: R26.2 U5.C3(DDR_A3)
PDDR_A4: R31.2 U5.C2(DDR_A4)
PDDR_A5: R32.2 U5.B1(DDR_A5)
PDDR_A6: R33.2 U5.D5(DDR_A6)
PDDR_A7: R34.2 U5.E2(DDR_A7)
PDDR_A8: R35.2 U5.D4(DDR_A8)
PDDR_A9: R36.2 U5.C1(DDR_A9)
PDDR_A10: R37.2 U5.F4(DDR_A10)
PDDR_A11: R38.2 U5.F2(DDR_A11)
PDDR_A12: R39.2 U5.E3(DDR_A12)
PDDR_A13: R40.2 U5.H3(DDR_A13)
PDDR_BA0: R41.2 U5.C4(DDR_BA0)
PDDR_BA1: R42.2 U5.E1(DDR_BA1)
PDDR_BA2: R43.2 U5.B3(DDR_BA2)
PDDR_CASN: R64.2 U5.F1(DDR_CASN)
PDDR_CKE: R62.2 U5.G3(DDR_CKE)
PDDR_CLK: R60.2 U5.D2(DDR_CK)
PDDR_CLKN: R61.2 U5.D1(DDR_NCK)
PDDR_CSN: R63.2 U5.H2(DDR_CSN0)
PDDR_D0: R44.2 U5.M3(DDR_D0)
PDDR_D1: R45.2 U5.M4(DDR_D1)
PDDR_D2: R46.2 U5.N1(DDR_D2)
PDDR_D3: R47.2 U5.N2(DDR_D3)
PDDR_D4: R48.2 U5.N3(DDR_D4)
PDDR_D5: R49.2 U5.N4(DDR_D5)
PDDR_D6: R50.2 U5.P3(DDR_D6)
PDDR_D7: R51.2 U5.P4(DDR_D7)
PDDR_D8: R52.2 U5.J1(DDR_D8)
PDDR_D9: R53.2 U5.K1(DDR_D9)
PDDR_D10: R54.2 U5.K2(DDR_D10)
PDDR_D11: R55.2 U5.K3(DDR_D11)
PDDR_D12: R56.2 U5.K4(DDR_D12)
PDDR_D13: R57.2 U5.L3(DDR_D13)
PDDR_D14: R58.2 U5.L4(DDR_D14)
PDDR_D15: R59.2 U5.M1(DDR_D15)
PDDR_DQM0: R67.2 U5.M2(DDR_DQM0)
PDDR_DQM1: R70.2 U5.J2(DDR_DQM1)
PDDR_DQS0: R68.2 U5.P1(DDR_DQS0)
PDDR_DQS1: R71.2 U5.L1(DDR_DQS1)
PDDR_DQSN0: R69.2 U5.P2(DDR_DQSN0)
PDDR_DQSN1: R72.2 U5.L2(DDR_DQSN1)
PDDR_ODT: R73.2 U5.G1(DDR_ODT)
PDDR_RASN: R65.2 U5.G4(DDR_RASN)
PDDR_WEN: R66.2 U5.B2(DDR_WEN)
PHY_VDDCR: C124.1 C125.1 U15.6(VDDCR)
PHY_XTAL1: C132.1 R140.2 R199.1 Y4.1
PHY_XTAL2: R140.1 R144.1 U15.4(XTAL2)
PHYX: C131.1 R144.2 Y4.2
PLLFILT: C145.1 U11.25(PLLFILT)
PMIC_INT: R10.2 R28.2 U5.B18(NNMI)
PMIC_INT_PU: R28.1 U14.7(2Y)
PMIC_INT_SRC: R10.1 R203.2 U2.45(INT) U14.1(2A) U14.2(2B)
PMIC_PGOOD: C25.1 R20.1 U2.26(PGOOD) U5.B15(PORZ)
PMIC_POWR_EN: U2.9(PWR_EN) U5.C6(PMIC_POWER_EN)
PWR_BUT: P9.9(5) U2.25(PB_IN)
PWR_LED: R6.1 U2.1(VLDO2)
PWR_LEDR: D1.2(A) R6.2 TP14.1(TP)
RBIAS: R145.1 U15.32(RBIAS)
RCLKIN: R199.2 R200.2 U15.5(XTAL1/CLKIN)
REFCLKO: R136.2 R209.2 U15.7(RXCLK/PHYAD1)
RESETN: C136.1 R156.2 U11.17(R\E\S\E\T\)
RMII1_COL: R207.1 U5.H16(GMII1_COL/RMII2_REFCLK/SPI1_SCL)
RMII1_CRS_DV: R139.1 U5.H17(GMII1_CRS/RMII1_CRS_DV/SPI1_D0/)
RMII1_REFCLK: R200.1 R201.2 R209.1
RMII1_RXCLK: R136.1 U5.L18(GMII1_RXCLK/UART2_TXD/RGMII1_RC)
RMII1_RXD0: R135.1 U5.M16(GMII1_RXD0/RMII1_RXD0/RGMII1_RD)
RMII1_RXD1: R132.1 U5.L15(GMII1_RXD1/RMII1_RXD1/RGMII1_RD)
RMII1_RXD2: R153.1 U5.L16(GMII1_RXD2/UART3_TXD/RGMII1_RD2)
RMII1_RXD3: R205.1 U5.L17(GMII1_RXD3/UART3_RXD/RGMII1_RD3)
RMII1_RXDV: R208.1 U5.J17(GMII1_RXDV/LCD_MEMORY_CLK/RGMII)
RMII1_RXERR: R137.1 U5.J15(GMII1_RXERR/RMII1_RXERR/SPI1_D1)
RMII1_TXCLK: R206.1 U5.K18(GMII1_TXCLK/UART2_RXD/RGMII1_TC)
RMII1_TXD0: U5.K17(GMII1_TXD0/RMII1_TXD0/RGMII1_TD) U15.22(TXD0)
RMII1_TXD1: U5.K16(GMII1_TXD1/RMII1_TXD1/RGMII1_TD) U15.23(TXD1)
RMII1_TXD2: U5.K15(GMII1_TXD2/DCAN0_RX/RGMII1_TD2/) U15.24(TXD2)
RMII1_TXD3: U5.J18(GMII1_TXD3/DCAN0_TX/RGMII1_TD3/) U15.25(TXD3)
RMII1_TXEN: U5.J16(GMII1_TXEN/RMII1_TXEN/RGMII1_TC) U15.21(TXEN)
RSVD3: R161.2 U11.15(VSS)
RTC_PORZ: R18.1 R141.1 R143.2 U5.B5(RTC_PORZ)
RTCK: P7.9(TCKRTN) R178.2
RXD0/MODE0: R124.1 R135.2 R198.1 U15.11(RXD0/MODE0)
RXD1/MODE1: R5.1 R123.1 R132.2 U15.10(RXD1/MODE1)
RXD2/RMIISEL: R153.2 R211.1 R212.1 U15.9(RXD2/RMIISEL)
RXD3/PHYAD2: R205.2 R213.1 R214.1 U15.8(RXD3/PHYAD2)
RXDV: R208.2 U15.26(RXDV)
RXER/PHYAD0: R125.1 R126.2 R137.2 U15.13(RXER/RXD4/PHYAD0)
RXN: C127.1 P10.2(RD-) R130.1 U15.30(RXN)
RXP: C126.1 P10.1(RD+) R129.1 U15.31(RXP)
SD_CD: P4.11(GND1) R196.1 R197.1
SPI1_CS0: P9.28(39) U5.C12(MCASP0_AHCLKR/EHRPWM0_SYNCI_O/M)
SPI1_D0: P9.29(15) U5.B13(MCASP0_FSX/EHRPWM0B//SPI1_D0/MM)
SPI1_D1: P9.30(40) U5.D12(MCASP0_AXR0/EHRPWM0_TRIPZONE_IN)
SPI1_SCLK: P9.31(16) U5.A13(MCASP0_ACLKX/EHRPWM0A//SPI1_SCL)
SYS_5V: C133.1 FB4.2 P9.7(4) P9.8(29) R3.2 R152.1 U2.7(SYS1) U2.8(SYS2) U9.2(IN#2) U9.3(IN#3)
SYS_RESETN: P9.10(30) R23.2 R27.1 U5.A10(NRESET_INOUT) U15.19(NRST)
SYS_VOLT: C6.1 C8.2 C9.2 C10.2 C17.2 C18.2 C19.2 R2.2 R3.1 U2.2(VINLDO) U2.21(VIN_DCDC1) U2.22(VIN_DCDC2) U2.32(VIN_DCDC3) U2.39(LDO3_IN) U2.42(LDO4_IN) U8.8(IN)
SYS_WARMRESETN: C101.1 R27.2 R163.2 S1.2(A2)
TCK: P7.11(TCK) R180.2
TCT_RCT: C130.1 P10.4(RCT) P10.5(TCT) R142.1
TDIS: P7.4(TDIS) R177.1
TESTOUT: TP6.1(TP) U5.A3(TESTOUT)
TIMER4: P8.7(4) U5.R7(GPMC_ADVN_ALE/TIMER4/GPIO2_2)
TIMER5: P8.9(5) U5.T6(GPMC_BE0N_CLE/TIMER5/GPIO2_5)
TIMER6: P8.10(30) U5.U6(GPMC_WEN/TIMER6/GPIO2_4)
TIMER7: P8.8(29) U5.T7(GPMC_OEN_REN/TIMER7/EMU4/GPIO2_)
TXCLK: R206.2 U15.20(TXCLK)
TXN: C129.1 P10.6(TD-) R134.1 U15.28(TXN)
TXP: C128.1 P10.3(TD+) R133.1 U15.29(TXP)
U5_H18: R201.1 U5.H18(RMII1_REFCLK/XDMA_EVENT_INTR2/S)
UART0_CTS: U5.E17(UART0_RTSN/UART4_TXD/DCAN1_RX/I) U12.40(BDBUS2)
UART0_RTS: U5.E18(UART0_CTSN/UART4_RXD/DCAN1_TX/I) U12.41(BDBUS3)
UART0_RX: U5.E16(UART0_TXD/SPI1_CS1/DCAN0_RX/I2C) U12.39(BDBUS1)
UART0_TX: U5.E15(UART0_RXD/SPI1_CS0/DCAN0_TX/I2C) U12.38(BDBUS0)
UART1_RXD: P9.26(38) U5.D16(UART1_RXD/MMC1_SDWP/DCAN1_TX/I2)
UART1_TXD: P9.24(37) U5.D15(UART1_TXD/MMC2_SDWP/DCAN1_RX/I2)
UART2_RXD: P9.22(36) U5.A17(SPI0_SCLK/UART2_RXD/I2C2_SDA/EH)
UART2_TXD: P9.21(11) U5.B17(SPI0_D0/UART2_TXD/I2C2_SCL/EHRP)
UART3_CTSN: P8.36(43) R90.2 R110.1 U5.U3(LCD_DATA10/GPMC_A14/EHRPWM1A/MC)
UART3_RTSN: P8.34(42) R91.2 R111.1 U5.U4(LCD_DATA11/GPMC_A15/EHRPWM1B/MC)
UART4_CTSN: P8.35(18) R92.2 R112.1 U5.V2(LCD_DATA12/GPMC_A16/EQEP1A_IN/M)
UART4_RTSN: P8.33(17) R93.2 R113.1 U5.V3(LCD_DATA13/GPMC_A17/EQEP1B_IN/M)
UART4_RXD: P9.11(6) U5.T17(GPMC_WAIT0/GM112_CRS/GPMC_CSN4/)
UART4_TXD: P9.13(7) U5.U17(GPMC_WPN/GMII2_RXERR/GPMC_CSN5/)
UART5_CTSN: P8.31(16) R94.2 R114.1 U5.V4(LCD_DATA14/GPMC_A18/EQEP1_INDEX)
UART5_RTSN: P8.32(41) R95.2 R115.1 U5.T5(LCD_DATA15/GPMC_A19/EQEP1_STROB)
UART5_RXD: P8.38(44) R89.2 R109.1 U5.U2(LCD_DATA9/GPMC_A13/EHRPWM1_SYNC)
UART5_TXD: P8.37(19) R88.2 R108.1 U5.U1(LCD_DATA8/GPMC_A12/EHRPWM1_TRIP)
USB0_DM: U5.N18(USB0_DM) U11.2(USBDM_DN2)
USB0_DP: U5.N17(USB0_DP) U11.3(USBDP_DN2)
USB0_ID: TP4.1(TP) U5.P16(USB0_ID)
USB0_VBUS: R152.2 U5.P15(USB0_VBUS) U16.4(2Y)
USB0_VBUS_PWR: U11.11(PRTPWR2) U16.3(2A)
USB1_DM: P2.2(P2) U5.R18(USB1_DM) U10.2(D-)
USB1_DP: P2.3(P3) U5.R17(USB1_DP) U10.1(D+)
USB1_DRVVBUS: R147.1 U5.F15(USB1_DRVVBUS/GPIO3_13) U9.4(EN)
USB1_ID: R146.1 U5.P17(USB1_ID)
USB1_OC: R148.2 U5.T16(GPMC_A10/GMII2_RXD1/RGMII2_RD1/) U9.5(O\C\)
USB1_VBUS: C134.1 P2.1(P1) U5.T18(USB1_VBUS) U9.6(OUT#6) U9.7(OUT#7) U9.8(OUT#8) U10.6(VBUS)
USB_DC: C2.1 P3.1(VB) R149.1 U2.12(USB)
USBDM_DN: P3.2(D-) U11.21(USBDM_UP)
USBDP_UP: P3.3(D+) U11.22(USBDP_UP)
USR0: Q1.2(5) R116.1 U5.V15(GPMC_A5/GMII2_TXD0/RGMII2_TD0/R)
USR1: Q1.5 R117.1 U5.U15(GPMC_A6/GMII2_TXCLK/RGMII2_TCLK)
USR2: Q2.2(5) R118.1 U5.T15(GPMC_A7/GMII2_RXCLK/RGMII2_RCLK)
USR3: Q2.5 R119.1 U5.V16(GPMC_A8/GMII2_RXD3/RGMII2_RD3/M)
VDCDC1: L1.2 R12.1 U2.19(VDCDC1)
VDCDC2: L2.2 R204.1 U2.24(VDCDC2)
VDCDC3: L3.2 R13.1 U2.29(VDCDC3)
VREFP_ADC: C28.1 C29.1 C30.1 R78.2 U5.B9(VREFP)
VRTC: C20.1 C21.1 C98.1 R77.1 U2.3(VLDO1) U5.D7(VDDS_RTC) U17.1(2A) U17.2(2B) U17.8(VCC)
VRTC_DET: R17.1 U17.7(2Y)
VRTC_DET_OUT: R143.1 U17.3(2Y)
VRTC_DETB: C22.1 R17.2 U17.5(2A) U17.6(2B)
WAKEUP: R11.2 R77.2 U5.C5(EXT_WAKEUP)
WP: R210.2 U7.7(WP)
XDMA_EVENT_INTR0: R183.1 U5.A15(EVENT_INTR0/TIMER4/CLKOUT1/SPI1)
XTALIN: C137.2 R160.1 U11.24(XTALIN/CLKIN) Y5.3
XTALOUT: C144.2 R160.2 U11.23(XTALOUT) Y5.1
XTIN: C153.2 U12.2(OSCIN) Y6.3(X3)
XTOUT: C155.2 U12.3(OSC0) Y6.1(X1)
YEL_C: P10.11(YELC) R16.2

Pads without a net: NOREF#5 1; NOREF#16 1; NOREF#22 1; NOREF#24 1; NOREF#25 1; NOREF#26 1; P3 4; P5 3; P7 6; P10 7; U1 3; U2 15 17 44; U5 B12 D3 D13 F16 H4 M15 P18 R14 T13 U16 V17; U6 A2 E2 R3 R7; U8 2 6 7; U10 3 5; U11 5 8 12; U12 22 24 27 29 33 34 36 43 44 45 46 48 52 53 54 55 57 58 60; U15 18; Y2 2 4; Y3 2 4; Y5 2 4; Y6 2 4

## Via types
v1: diameter 0.457, hole 0.203, TOP to BOTTOM, 795 vias
v2: diameter 0.559, hole 0.305, TOP to BOTTOM, 23 vias
v3: diameter 0.635, hole 0.305, TOP to BOTTOM, 5 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
3V3EXP_FB: length 7.6
  TOP w0.121: U8.3 12.95,8.25 12.7,8 v1(12.7,7.11)
  BOTTOM w0.121: R189.1 R150.1 13.72,7.11 v1(12.7,7.11) 12.7,8.13 12.95,8.38 C166.1
AGND: length 2.6
  TOP w0.203: v1(26.08,20.95) 26.08,20.13 26,20.06 U2.41
  BOTTOM w0.381: R15.1 26.35,21.23 v1(26.08,20.95)
DGND: length 422.5
  TOP w0.203: U2.30 27,16.31 v2(26.8,16.51)
  TOP w0.305: U5.L11 v1(47.93,35.89) U5.M12 ; v1(51.13,33.49) U5.J8 ; v1(51.93,37.49) U5.N7 ; v1(50.33,33.49) U5.J9 ; U6.H8 74.33,34.29 v1(74.73,34.69) ; U5.J6 v1(52.73,33.49) U5.H6 ; U5.M14 v1(45.53,36.69) U5.N14 ; v1(48.73,35.09) U5.K10 ; v1(48.73,35.09) U5.L10 ; v1(48.73,35.09) U5.K11 ; v1(46.35,6.35) 46.35,6.79 46.33,6.81 U12.11 ; v1(46.35,6.35) 45.97,6.35 45.84,6.49 U12.10 ; v1(46.35,6.35) v1(46.99,6.35) 47.12,6.35 47.33,6.57 U12.13 ; U14.4 31.55,24.94 31.37,24.77 v1(31.11,24.77) ; v1(33.53,44.96) 33.77,45.2 Q1.4 ; v1(47.13,32.69) U5.H12 ; U5.G11 48.17,32.13 47.69,32.13 U5.G12 v1(47.13,31.89) ; v1(73.93,33.09) 73.93,33.09 U6.J7 ; U5.K7 U5.J7 v1(51.93,33.49) ; U12.15 48.33,9.09 v1(48.77,9.53) ; U5.N11 v1(48.73,37.49) U5.N10 ; U6.B8 v1(73.93,39.49) 73.53,39.89 U6.A7 ; U5.M6 v1(51.93,35.89) U5.M7 ; U5.H10 v1(48.73,33.49) U5.J10 ; U5.A18 v1(42.73,26.92) ; v1(48.73,36.69) U5.M10 ; U5.F8 v1(50.33,31.89) U5.G9 ; Q2.1 28.46,47.51 v1(28.7,47.75) ; U5.V1 v1(56.33,41.78) ; U6.N1 v1(68.33,29.89) ; U11.6 21.95,39.73 v2(22.23,40.01) ; U12.51 38.56,16.09 38.35,15.88 v1(38.1,15.88) ; U5.M8 v1(50.33,36.69) U5.M9 ; U6.J3 v1(69.93,33.09) ; v1(49.15,14.61) 48.64,15.11 48.64,16.64 48.9,16.89 49.2,16.89 49.39,17.09 U12.32 ; v1(44.13,9.53) 43.33,8.73 U12.5 ; v1(32,21.21) 32,21.67 31.88,21.79 U17.4 ; Q2.4 29.96,45.2 v1(29.72,44.96) ; U5.J11 v1(47.93,33.49) ; v1(51.13,32.69) U5.H8 ; U5.G8 v1(50.33,32.69) U5.H9 ; U6.D8 v1(73.93,37.09) U6.E7 ; U6.D2 v1(69.13,37.89) ; U6.A3 v1(69.93,40.29) ; U5.V18 v1(41.91,41.09) ; U5.A1 v1(56.33,26.8) ; U12.35 47.84,17.86 v1(47.62,17.65) ; v1(74.73,36.29) 74.33,35.89 U6.F8 ; U6.F2 v1(69.13,36.29) ; U6.P9 v1(75.53,29.09) ; v1(41.27,9.53) 41.33,9.47 U12.1 ; Q1.1 32.27,47.51 v1(32.51,47.75) ; U6.H2 v1(69.13,34.69) ; U5.L12 v1(47.13,35.89) U5.L13 ; U5.H7 v1(51.93,32.69) ; U1.6 16.5,12.56 v1(16.76,12.83) ; v1(41.91,17.65) 41.84,17.73 U12.47 ; U1.2 v1(13.59,12.06) ; U6.E3 v1(69.93,37.09) ; v1(50.33,35.09) U5.K9 ; U12.25 v1(49.15,13.58) ; U6.B2 v1(69.13,39.49)
  TOP w0.381: C111.2 v1(79.25,37.09) ; 36.83,41.27 36.83,42.29 37.08,42.55 C51.2 C52.1 ; 36.83,41.27 v1(36.83,40.64) v1(37.47,40.64) 37.47,41.15 C52.1 ; 36.83,41.27 C52.1 ; C113.2 v1(79.25,33.09) ; 48.58,45.85 v1(48.58,45.09) ; C160.2 v1(80.52,35.56) ; C145.2 14.8,40.32 14.61,40.13 v1(14.61,39.69) ; C162.1 v1(38.73,20.32) ; v1(79.25,32) 79.13,31.89 C114.2 ; R79.1 v1(54.93,21.91) ; R161.1 v1(23.5,47.75) ; v1(2.16,42.42) 2.16,41.13 S1.1 ; C110.2 78.91,38.69 v1(79.25,38.35) ; v1(2.41,14.48) 2.41,15.49 D1.1 ; C109.2 v1(79.12,40.29) ; 64.77,45.85 v1(64.77,45.09) ; U16.2 v1(30.86,41.91) ; C163.1 38.61,6.99 v1(36.51,6.99) ; C144.1 v1(13.34,43.18) ; C115.2 v1(79.25,30.69) ; C146.2 v1(27.56,40.01) ; v1(19.68,47.75) R159.2 C136.2 ; R158.2 v1(27.56,42.55) ; C101.2 6.99,42.16 6.73,42.42 v1(5.71,42.42) ; U8.4 14.65,7.6 v3(14.73,7.68) ; C100.2 v1(13.02,48.26) ; C89.1 v1(79.69,42.55) ; C137.1 v1(17.14,41.27) ; C117.2 v1(79.25,29.49) ; C116.2 v1(64.33,42.55) ; C159.2 v1(80.52,33.15) ; C112.2 v1(79.25,35.49)
  TOP w0.762: C133.2 70.54,20.34 P2.4
  LYR2_GND w0.889: 72.29,5.18 P9.44 ; P9.44 72.29,3.71 ; P9.44 73.76,3.71 ; P9.44 73.76,5.18 ; TP1.1 61.87,21.23 ; TP1.1 60.05,21.23 ; TP1.1 60.05,19.41 ; 5.18,7.42 P5.2 ; P5.2 5.18,11.63 ; P5.2 6.27,9.53 ; P5.2 4.09,9.53 ; 74.83,2.64 P9.45 76.3,2.64 ; 18.72,49.2 P8.1 ; P8.1 20.65,51.13 ; P8.1 20.65,49.2 ; P8.1 18.72,51.13 ; 18.95,5.18 P9.2 ; P9.2 20.42,3.71 ; P9.2 20.42,5.18 ; P9.2 18.95,3.71 ; 72.29,2.64 P9.43 73.76,2.64 ; 72.59,21.11 P2.4 ; P2.4 74.15,21.11 ; P2.4 74.15,19.56 ; P2.4 72.59,19.56 ; 74.83,5.18 P9.46 ; P9.46 76.3,5.18 ; P9.46 74.83,3.71 ; P9.46 76.3,3.71 ; 20.42,51.97 P8.2 18.95,51.97 ; 20.65,2.87 P9.1 18.72,2.87 ; 16.45,26.1 P10.8 ; P10.8 17.84,24.7 ; P10.8 16.45,24.7 ; P10.8 17.84,26.1
  BOTTOM w0.191: 29.75,32.86 31.78,32.86 31.94,33.02 R125.2
  BOTTOM w0.254: C82.2 49.5,28.58 48.73,29.35 v1(48.73,29.49)
  BOTTOM w0.305: C65.1 v1(51.93,37.49) 51.24,37.49 C35.2 ; C91.2 52.73,34.18 v1(52.73,33.49) ; v1(50.33,36.69) 50.04,36.98 C34.2 ; C40.2 49.39,33.49 v1(48.73,33.49) ; v1(47.13,31.89) 47.82,31.89 C45.2 ; C60.2 45.53,36 v1(45.53,36.69) 45.53,37.38 C33.2 ; v1(51.93,35.89) C90.2 ; U10.4 80.51,18.91 v1(80.64,19.05) ; C64.1 50.04,31.6 v1(50.33,31.89) ; v1(50.33,35.09) 49.64,35.09 C38.2 ; C92.2 v1(51.93,32.69) ; C37.2 48.44,34.8 v1(48.73,35.09) ; v1(46.33,30.29) 46.44,30.4 C62.1 ; C58.1 v1(47.13,32.69) ; v1(51.93,33.49) 51.64,33.78 C39.2 ; v1(52.73,30.29) 52.73,30.98 C93.2 ; C88.2 v1(47.93,35.89) ; C41.2 v1(51.13,32.69) ; v1(44.13,9.53) R167.1 ; C96.2 v1(56.77,34.29)
  BOTTOM w0.381: C106.2 v1(65.28,35.49) ; R118.2 v1(29.72,44.96) ; C152.2 46.04,14.85 45.79,14.61 v1(45.34,14.61) ; 26.16,9.27 26.16,10.29 25.91,10.54 U7.4 22.99,10.54 R1.1 ; 26.16,9.27 24.57,9.27 ; 26.16,9.27 26.16,8 ; R18.2 v1(32.07,27.3) ; R177.2 C154.2 v1(59.63,9.53) ; v1(36.2,14.86) C15.1 ; C78.2 v1(40.51,37.49) 40.51,38.35 41.25,39.09 R146.2 ; v1(37.3,27.94) 37.3,29.12 C31.1 36.89,29.53 R214.2 R212.2 ; R103.2 R102.2 v1(61.91,47.62) ; v1(24.77,5.84) 24.77,6.73 ; 24.77,6.73 25.91,6.73 26.16,6.99 26.16,8 ; 24.77,6.73 24.57,6.73 ; C76.2 C77.2 C79.2 ; C76.2 C49.2 ; C76.2 40.91,29.89 40.56,29.54 v1(40.51,29.54) ; R127.2 35.43,35.56 v1(35.18,35.81) ; C72.2 v1(32.51,40.01) ; TP1.1 R76.1 ; R216.2 R145.2 v1(19.68,29.53) ; R115.2 R114.2 v1(50.48,47.62) ; v1(48.77,9.53) 49.53,10.29 50.16,10.29 ; C131.2 v1(21.46,25.53) ; C121.2 25.78,33.02 v2(26.04,33.27) 26.29,33.02 C123.2 27.11,33.4 27.37,33.66 28.96,33.66 29.75,32.86 ; v1(63.82,47.62) R100.2 R101.2 ; C22.2 v1(33.97,23.81) ; C99.2 47.93,42.4 47.8,42.27 46.46,42.27 C56.2 ; v2(19.68,40.01) 19.56,39.88 C143.2 ; C94.2 v1(79.69,42.55) ; C108.2 v1(65.28,28.29) ; v2(26.04,31.5) 26.29,31.75 C125.2 ; v2(26.04,31.5) 25.78,31.75 C120.2 C119.2 ; v2(26.04,31.5) 26.42,31.11 26.42,30.61 C124.2 ; C104.2 v1(65.28,38.69) ; R198.2 R5.2 R212.2 ; v1(52.39,47.62) R113.2 R111.2 ; C105.2 v1(65.28,37.09) ; v1(34.42,6.99) 34.42,8.45 33.97,8.89 U13.2 32.26,8.89 31.5,8.13 C102.2 ; C165.1 21.46,14.86 21.84,14.48 C2.2 22.54,15.02 22.76,15.24 v2(23.5,15.24) ; 71.82,15.88 71.82,18.1 71.5,18.41 P7.20 ; 71.82,15.88 P7.16 ; 71.82,15.88 71.82,13.34 ; R20.2 C157.1 ; R20.2 C25.2 ; R20.2 v1(29.21,27.3) ; FB3.2 v1(47.62,17.65) ; C7.2 v1(10.16,13.97) C3.1 ; 16.26,7.24 16.64,7.24 17.02,6.86 R189.2 ; C134.2 v1(81.92,19.68) ; v1(40.51,34.29) 40.91,33.89 C71.1 C73.2 ; v1(36.83,40.64) 36.83,41.53 C69.2 37.47,41.66 v1(37.47,40.64) ; v1(36.83,40.64) v1(37.47,40.64) ; v1(36.83,40.64) 36.83,40.13 37.08,39.88 C61.2 37.47,40.01 v1(37.47,40.64) ; C56.2 v1(46.33,43.18) ; C56.2 C74.2 ; v1(54.93,21.91) 54.67,21.91 53.02,23.56 C97.2 C86.2 C98.2 C83.2 C85.2 C84.2 C57.2 46.48,24.26 46.23,24.51 v1(46.23,26.15) ; C164.1 v1(46.99,6.35) v1(46.35,6.35) 45.72,6.35 45.4,6.67 C161.2 ; v1(40.51,32.69) 40.71,32.89 C73.2 ; C139.2 v2(22.23,40.01) 22.1,39.88 C141.2 ; v1(37.21,23.75) 37.21,24 C53.2 ; 71.82,13.34 v1(71.82,12.06) ; 71.82,13.34 69.7,13.34 ; v1(71.82,12.06) v1(71.82,10.79) P7.8 ; v1(71.82,12.06) P7.10 ; C32.1 v1(37.21,32.77) ; C10.1 v1(28.26,20.32) R9.1 ; v3(15.24,8.57) 15.43,8.38 C6.2 ; v1(42.99,20.32) 42.99,20.76 C46.2 ; C142.2 20.83,42.67 v2(20.95,42.55) ; C149.1 31.37,41.4 v1(30.86,40.89) ; C147.2 49.37,15.37 49.15,15.14 v1(49.15,14.61) ; C132.2 26.35,24.96 26.67,24.64 27.06,24.64 27.3,24.39 v1(27.3,23.81) ; R212.2 v1(36.45,30.48) ; R186.2 v1(59.63,6.99) ; C73.2 C48.2 C49.2 ; C153.1 v1(37.47,9.53) C155.1 ; C20.2 v1(19.68,20.32) ; U9.1 v1(75.59,13.63) ; C43.1 49.53,41.4 50.53,42.4 C75.2 v1(51.13,43.18) ; 32.85,19.3 C50.1 v1(33.97,20.45) ; 32.85,19.3 32.85,20.28 v1(33.02,20.45) ; 32.85,19.3 C14.1 32,19.56 v1(32,20.45) ; v1(65.28,33.09) C107.2 C118.2 ; R110.2 R112.2 v1(54.29,47.62) ; v1(40.51,31.19) 40.51,31.09 40.71,30.89 C49.2 ; C36.2 C81.2 v1(40.51,35.89) ; C138.2 v2(22.23,42.55) ; C63.1 42.42,41.4 42.11,41.09 v1(41.91,41.09) 41.62,41.09 41.42,40.89 C80.2 ; v1(37.21,26.16) 37.21,25.78 C54.2 ; C127.2 v1(10.67,33.02) ; U7.2 26.16,8 ; v1(6.22,30.23) 5.4,30.23 R138.1 5.4,29.46 v1(6.22,29.46) ; v1(6.22,30.23) R128.1 ; v1(6.22,30.23) v1(6.22,29.46) ; R107.2 R106.2 v1(58.1,47.62) ; R157.2 14.85,39.05 14.61,39.3 v1(14.61,39.69) ; v2(25.15,15.24) 26.1,15.24 C8.1 C9.1 ; C156.2 62.1,15.24 v1(62.36,15.24) ; C130.2 v1(10.67,30.48) ; C66.1 v1(54.33,43.15) ; v2(26.8,16.51) 26.6,16.51 26.35,16.76 C18.1 C17.1 24.45,16.83 24.13,16.51 v2(23.5,16.51) ; v1(16.76,12.83) 16.51,12.57 C1.2 ; v1(42.73,26.92) 43.31,26.35 43.31,25.15 C44.1 ; v1(6.22,29.46) R16.1 R219.2 ; C136.2 v1(20.95,47.75) ; C129.2 v1(10.67,27.94) ; C122.2 23.94,34.73 23.37,35.31 v1(23.37,35.81) ; 64.77,45.85 v1(64.77,45.09) ; v1(23.37,20.95) 23.62,21.21 23.62,21.65 C135.1 ; v1(21.46,19.56) 22.23,19.56 C19.1 ; C150.2 v1(41.91,17.65) ; 48.58,45.85 v1(48.58,45.09) ; 20.32,8 20.32,6.6 v1(19.68,5.97) ; C95.2 v1(64.33,42.55) ; P4.6 80.76,35.32 v1(80.52,35.56) ; R15.2 v1(26.35,23.81) ; v1(9.91,45.34) 9.19,46.05 P3.5 ; C128.2 v1(10.67,31.75) ; v1(56.2,47.62) R108.2 R109.2 ; C55.2 v1(30.16,19.94) ; C70.1 v1(52.73,43.18) ; C21.2 v1(34.92,21.21) ; C103.2 v1(65.28,40.29) ; R116.2 v1(33.53,44.96) ; v1(76.71,37.85) 76.45,37.85 76.2,38.1 76.2,38.84 75.95,39.09 P4.9 ; v1(60.01,47.62) R104.2 R105.2 ; R147.2 v1(76.83,19.68) ; v1(19.05,23.75) C4.1 C5.1 ; C126.2 v1(10.67,34.29) ; C140.2 v2(22.23,41.27) ; R117.2 v1(32.51,47.75) ; R119.2 v1(28.7,47.75) ; C148.2 v1(44.13,14.61) ; C158.2 v1(42.86,6.35) ; R75.2 v1(64.01,33.66)
  BOTTOM w0.762: P8.1 P8.2 ; P9.45 P9.46 ; P9.1 P9.2
  vias: v1(48.64,21.84) v2(19.68,42.55) v2(19.68,41.27) v2(20.95,41.27) v2(20.95,40.01) v2(25.15,32.38) v2(25.15,16.51) v2(26.04,32.38) v2(26.92,32.38) v2(78.74,15.24) v2(78.74,13.97) v2(80.01,15.24) v2(80.01,13.97) v3(14.73,9.46) v3(15.75,9.46) v3(15.75,7.68)
GND_EARTH: length 190.2
  TOP w0.381: S1.3 v1(3.81,38.1)
  TOP w0.889: 12.84,4.94 MTG1.1 ; MTG1.1 12.84,1.41 ; MTG1.1 16.37,1.41 ; MTG1.1 16.37,4.94 ; 78.88,50.03 MTG4.1 ; MTG4.1 78.88,46.49 ; MTG4.1 82.41,46.49 ; MTG4.1 82.41,50.03 ; 12.84,49.67 MTG3.1 ; MTG3.1 16.37,53.2 ; MTG3.1 12.84,53.2 ; MTG3.1 16.37,49.67 ; MTG2.1 82.41,8.12 ; MTG2.1 78.88,4.58 ; MTG2.1 78.88,8.12 ; MTG2.1 82.41,4.58
  LYR2_GND w0.889: 78.88,46.49 MTG4.1 ; MTG4.1 82.41,50.03 ; MTG4.1 78.88,50.03 ; MTG4.1 82.41,46.49 ; MTG2.1 82.41,8.12 ; MTG2.1 82.41,4.58 ; MTG2.1 78.88,8.12 ; MTG2.1 78.88,4.58 ; 12.84,49.67 MTG3.1 ; MTG3.1 12.84,53.2 ; MTG3.1 16.37,53.2 ; MTG3.1 16.37,49.67 ; 12.84,4.94 MTG1.1 ; MTG1.1 16.37,4.94 ; MTG1.1 12.84,1.41 ; MTG1.1 16.37,1.41
  LYR5_PWR w0.889: MTG2.1 82.41,4.58 ; MTG2.1 78.88,4.58 ; MTG2.1 78.88,8.12 ; MTG2.1 82.41,8.12 ; MTG4.1 82.41,46.49 ; MTG4.1 82.41,50.03 ; MTG4.1 78.88,50.03 ; MTG4.1 78.88,46.49 ; 12.84,53.2 MTG3.1 ; MTG3.1 12.84,49.67 ; MTG3.1 16.37,49.67 ; MTG3.1 16.37,53.2 ; MTG1.1 16.37,1.41 ; MTG1.1 12.84,4.94 ; MTG1.1 12.84,1.41 ; MTG1.1 16.37,4.94
  BOTTOM w0.381: v1(1.91,30.23) 2.86,30.23 R138.2 2.86,29.46 v1(1.91,29.46) ; P4.12 72.01,29.62 72.52,29.11 72.52,24.51 73.66,23.37 76.04,23.37 P2.6 ; P4.10 70.94,39.95 72.14,41.15 84.58,41.15
  BOTTOM w0.889: MTG4.1 82.41,50.03 ; MTG4.1 82.41,46.49 ; MTG4.1 78.88,50.03 ; MTG4.1 78.88,46.49 ; MTG2.1 82.41,8.12 ; MTG2.1 78.88,4.58 ; MTG2.1 78.88,8.12 ; MTG2.1 82.41,4.58 ; 12.84,49.67 MTG3.1 ; MTG3.1 16.37,53.2 ; MTG3.1 12.84,53.2 ; MTG3.1 16.37,49.67 ; MTG1.1 16.37,1.41 ; MTG1.1 16.37,4.94 ; MTG1.1 12.84,4.94 ; MTG1.1 12.84,1.41
  vias: v1(3.05,50.8) v1(3.05,38.1) v1(3.81,50.8) v1(7.24,50.8) v1(7.24,38.1) v1(8,50.8) v1(8,38.1)
GND_OSC0: length 6.8
  TOP w0.305: v1(47.12,42.8) 48.33,41.59 U5.V11
  TOP w0.381: v1(41.4,44.58) 40.64,45.34 40.64,45.85 ; v1(43.69,48.13) 44.07,48.13 44.45,47.75 C26.2
  BOTTOM w0.381: 47.12,44.01 v1(47.12,42.8)
GND_OSC1: length 12
  TOP w0.305: 53.13,27.13 U5.A5
  TOP w0.381: 56.52,19.94 56.52,20.38 55.94,20.95 54.61,20.95 53.34,22.23 53.34,25.59 53.63,25.88 53.63,26.63 53.13,27.13
  BOTTOM w0.381: C23.1 v1(55.24,16.51) ; C24.1 v1(57.78,16.51)
GNDA_ADC: length 43.9
  TOP w0.305: U5.A9 49.93,27.05 ; v1(51.13,30.29) U5.E8
  TOP w0.381: v1(47.62,21.84) C30.2 C29.2 C28.2 C87.2 ; C87.2 v1(50.48,21.84) ; C87.2 50.93,22.67 51.09,22.83 51.09,24.48 50.29,25.27 50.29,26.44 49.93,26.8 49.93,27.05
  LYR4 w0.381: P9.34 58.29,6.48 58.29,8.76 55.12,11.94 55.12,15.24 53.47,16.89 52.96,16.89 52.45,17.4 52.45,19.43 50.48,21.4 v1(50.48,21.84) 50.48,27.5 49.66,28.32 49.66,29.84 50.1,30.29 v1(51.13,30.29)
  BOTTOM w0.381: FB3.1 v1(47.62,21.84)
VBUS_DET: length 3.4
  TOP w0.121: U11.18 v1(20.95,44.96)
  BOTTOM w0.121: v1(20.95,44.96) 20.95,45.85 19.68,45.85
VDD_1V8: length 69
  TOP w0.305: v1(45.53,38.29) U5.P14 ; v1(47.13,35.09) U5.K13 ; U5.E9 v1(50.33,31.09) U5.F9 ; U5.E14 v1(45.53,30.29) ; v1(43.93,37.49) U5.N16 ; v1(43.93,39.09) U5.R16 ; U5.N6 v1(51.93,36.69) ; U5.E7 v1(51.93,30.29) U5.E6 ; v1(50.33,38.29) U5.P9 ; v1(48.73,30.29) U5.D10
  TOP w0.508: v1(20.57,13.21) 20.32,13.46 TP15.1 R12.2 19.43,11.68 v1(19.56,11.56)
  LYR3 w0.762: v1(50.8,17.65) v1(50.04,17.65) 48.77,18.92 35.69,18.92 30.73,13.97 30.73,12.45 29.84,11.56 21.46,11.56 ; 20.57,11.56 21.46,11.56 ; 20.57,11.56 v1(19.56,11.56) ; 20.57,11.56 20.57,12.45 ; 21.46,11.56 v1(21.46,12.45) 20.57,12.45 ; v1(20.57,13.21) 20.57,12.45
  BOTTOM w0.121: 45.13,38.69 45.13,40.34
  BOTTOM w0.305: C74.1 44.73,40.74 45.13,40.34 ; v1(45.53,38.29) 45.13,38.69 ; v1(48.73,30.29) 49.42,29.6 C82.1 49.66,29.6 50.33,30.26 v1(50.33,31.09) ; v1(43.93,37.49) C78.1 ; v1(43.93,39.09) 42.7,40.32 C80.1
  BOTTOM w0.381: v1(36.83,39.24) 36.83,38.42 FB1.1 37.47,38.41 v1(37.47,39.24) v1(36.83,39.24) ; v1(36.83,39.24) C72.1 ; v1(50.8,17.65) 50.67,17.78 50.67,18.54 50.48,18.74 FB2.2 50.04,18.61 v1(50.04,17.65) v1(50.8,17.65)
  vias: v1(43.93,31.09)
VDD_1V8FT: length 34.8
  TOP w0.305: C163.2 39.49,8.88 U12.64 40.57,9.58 41.91,10.92 v1(41.91,12.95) ; U12.37 46.84,17.53 46.74,17.43 v1(46.74,16.38) ; C162.2 39.49,17.79 U12.49 40.51,17.09 ; v1(46.84,9.53) U12.12
  TOP w0.381: 40.51,17.09 41.53,16.07 41.53,13.34 v1(41.91,12.95)
  LYR3 w0.381: v1(46.84,9.53) 46.84,10.8 46.59,11.05 43.81,11.05 v1(41.91,12.95)
  BOTTOM w0.381: C164.2 46.99,9.37 v1(46.84,9.53) 46.74,9.62 v1(46.74,16.38) C152.1
VDD_3V3A: length 95.7
  TOP w0.203: U2.18 25.2,12.89 24.75,12.45 v1(24.64,12.45)
  TOP w0.305: U5.H14 v1(45.53,33.49) U5.J14 ; U5.L14 v1(46.33,35.09) U5.K14 ; U5.F14 v1(45.53,31.89) U5.G14 ; U5.P6 v1(52.73,38.29) ; U5.P8 U5.P7 v1(51.93,38.29) ; v1(44.73,37.49) U5.N15 ; U5.E10 v1(48.73,31.09) U5.E11 v1(47.93,30.29) U5.E12 v1(47.13,30.29) U5.E13 ; U5.P5 v1(53.53,38.29) ; U5.P12 v1(47.13,38.29) ; U5.P13 v1(46.33,38.29) ; U5.P11 v1(48.73,38.29) U5.P10 ; v1(44.73,39.09) U5.R15 ; U5.N5 v1(52.73,36.69)
  TOP w0.381: R84.1 R85.1 v1(59.05,47.62) ; R80.1 R81.1 v1(62.87,47.62) ; R95.1 v1(49.53,47.62) ; 39.37,41.27 v1(39.37,40.64) v1(38.73,40.64) 38.73,41.15 C52.2 ; 39.37,41.27 39.37,42.29 39.12,42.55 C51.1 C52.2 ; 39.37,41.27 C52.2 ; R193.1 v1(83.69,36.58) ; v1(83.69,36.58) v1(83.69,37.59) R194.1 ; v1(83.69,36.58) v1(83.69,35.56) ; R190.1 v1(83.69,29.72) v1(83.69,30.73) ; v1(55.24,47.62) R89.1 R88.1 ; R93.1 R91.1 ; R91.1 R94.1 ; R91.1 v1(51.44,47.62) ; v1(57.15,47.62) R87.1 R86.1 ; v1(83.69,35.56) v1(83.69,34.54) ; v1(83.69,35.56) C160.1 ; v1(83.69,34.54) R192.1 ; v1(83.69,34.54) 83.69,33.53 C159.1 83.69,32.77 v1(83.69,31.75) ; R195.1 v1(83.69,30.73) ; v1(83.69,30.73) v1(83.69,31.75) ; v1(18.03,5.97) 17.65,5.97 16.71,6.91 U8.5 ; v1(60.96,47.62) R83.1 R82.1 ; R92.1 R90.1 v1(53.34,47.62) ; v1(10.29,40.32) 10.16,40.45 R23.1 ; v1(83.69,31.75) R191.1 ; C67.2 v1(48.58,47.62) ; C68.2 v1(64.77,47.62)
  LYR4 w0.381: v1(18.03,5.97) 17.4,6.6 17.4,14.99 v1(19.18,16.76)
  BOTTOM w0.305: C65.2 53.53,37.6 v1(53.53,38.29) ; v1(44.73,37.49) 43.73,36.49 43.62,36.49 43.02,35.89 C81.1 ; v1(48.73,31.09) 49.24,30.58 C64.2 ; v1(45.53,33.49) 45.53,32.8 C58.2 45.53,32.58 v1(45.53,31.89) 45.53,31.2 C62.2 ; v1(48.73,38.29) 49.42,38.98 C43.2 ; C60.1 46.44,35.2 v1(46.33,35.09)
  BOTTOM w0.381: 83.69,33.12 P4.4 ; 83.69,33.12 v1(83.69,31.75) ; 83.69,33.12 v1(83.69,34.54) ; C63.2 v1(40.51,41.91) ; v1(38.73,40.64) 38.73,40.01 C61.1 39.12,39.88 39.37,40.13 v1(39.37,40.64) ; v1(38.73,40.64) 38.73,41.66 38.99,41.91 39.37,41.53 v1(39.37,40.64) ; v1(38.73,40.64) v1(39.37,40.64) ; v1(32.38,13.46) R7.1 R4.1 ; v1(19.18,16.76) 20.19,16.76 C165.2 20.57,16.89 R19.2 ; C68.2 v1(64.77,47.62) ; C67.2 v1(48.58,47.62) ; C57.1 v1(46.99,26.16)
VDD_3V3B: length 98.6
  TOP w0.254: v1(29.34,32.14) 28.95,32.14 U15.12 ; v1(33.97,27.3) 34.29,27.3 34.42,27.18 34.42,26.86 U14.8
  TOP w0.305: U12.56 v1(40.89,13.58) ; U11.4 v1(20.95,37.85) ; U12.31 49.73,16.58 49.53,16.38 v1(49.15,16.38) 49.15,15.49 49.56,15.09 U12.28 ; v1(19.68,44.69) 19.96,44.42 U11.20 ; v1(44.13,17.65) 44.33,17.86 U12.42 ; v1(17.65,39.05) 17.65,40.01 17.92,40.28 U11.27 ; v1(24.38,40.64) 24.24,40.77 U11.10 ; v1(49.15,11.09) U12.20 ; U11.14 23.98,42.78 v1(24.38,43.18)
  TOP w0.381: R154.1 v1(27.56,41.27) ; R176.1 61.28,11.81 v1(62.29,10.79) ; R181.1 v1(33.66,11.75) ; R155.1 v1(18.41,47.75) ; v1(35.05,41.91) U16.5 ; R187.1 v1(36.51,7.94) ; R173.1 R174.1 33.46,9.84 32.89,10.41 v1(32.89,10.79) ; R156.1 v1(22.23,47.75)
  LYR4 w0.381: v1(83.19,19.68) 83.19,20.95 82.55,21.59 69.34,21.59 69.09,21.34 v1(69.09,21.34)
  BOTTOM w0.191: R126.1 35.43,33.69 35.31,33.81 33.5,33.81 33.02,34.29 v1(32.64,34.29) ; v1(29.34,32.14) 29.56,31.91 31.94,31.91
  BOTTOM w0.381: v1(42.16,14.61) 41.91,14.86 C150.1 ; R121.2 v1(25.4,23.81) 24,23.81 C135.2 ; 29.78,6.73 31.37,6.73 C102.1 v1(32.13,6.86) ; v1(43.18,13.84) FB7.1 FB6.1 v1(45.4,13.84) ; R124.2 R123.2 R211.2 ; v1(19.68,44.69) 19.81,44.56 C142.1 ; C139.1 24.38,40.06 v1(24.38,40.64) 24.38,41.22 C140.1 ; R213.2 34.42,27.75 v1(33.97,27.3) R162.1 ; R175.1 48.93,11.3 v1(49.15,11.09) 49.37,11.3 C151.1 ; v1(28.45,37.21) FB5.1 27.56,36.64 v1(27.56,35.81) 27.56,35.31 27.11,34.86 R131.1 C122.1 ; v1(69.09,21.34) 69.09,21.34 69.34,21.59 R196.2 ; v1(35.05,41.91) 34.54,41.4 C149.2 ; v1(19.68,25.53) 19.68,27.05 20.26,27.62 R215.2 ; v1(40.89,13.58) 40.26,13.58 40.01,13.84 FB8.1 ; R203.1 v1(30.16,23.81) ; C141.1 21.08,37.97 v1(20.95,37.85) ; R148.1 v1(83.19,19.68) ; C123.1 28.7,33.02 29.34,32.38 v1(29.34,32.14) ; C148.1 v1(44.13,17.65) ; v1(28.26,24.77) C157.2 ; v1(32.89,10.79) 31.88,10.79 R210.1 ; C154.1 v1(62.29,9.53) P7.5 ; C143.1 v1(17.65,39.05) ; v1(36.51,7.94) U13.6 ; C147.1 v1(49.15,16.38) ; R179.1 v1(62.29,10.79) ; v1(24.38,43.18) 24.38,42.61 C138.1 ; R122.2 v1(32.64,34.29)
VDD_3V3EXP: length 20.2
  TOP w0.381: U8.1 13.72,9.6 v1(13.72,10.16)
  LYR4 w0.381: P9.4 21.08,3.3 18.92,3.3 18.41,3.81 18.41,4.45 16.51,6.35 13.72,6.35 ; v1(13.72,10.16) 13.72,6.35 ; 13.72,6.35 v1(12.7,6.35)
  BOTTOM w0.381: R150.2 v1(12.7,6.35) ; C166.2 13.46,9.9 13.72,10.15 v1(13.72,10.16)
  BOTTOM w0.762: P9.3 P9.4
VDD_5V: length 18
  LYR3 w0.762: v1(14.73,13.34) v1(15.49,13.34) 15.49,11.68 16.26,10.92 17.14,10.92 19.56,8.51 21.97,8.51 23.75,6.73 23.75,5.46 P9.6
  BOTTOM w0.762: P9.5 P9.6
VDD_ADC: length 36
  TOP w0.305: v1(51.13,29.49) U5.D8
  TOP w0.381: C87.1 50.48,24.31 50.03,24.77 R78.1 49.64,24.84 v1(49.64,26.16)
  LYR3 w0.381: v1(49.64,26.16) 49.66,26.18 49.66,29.72 50.04,30.1 50.52,30.1 v1(51.13,29.49)
  LYR4 w0.381: P9.32 57.78,8.51 54.61,11.68 54.61,14.99 53.21,16.38 52.7,16.38 51.94,17.14 51.94,19.05 49.66,21.34 v1(49.66,21.84) 49.64,21.87 v1(49.64,26.16)
  BOTTOM w0.381: FB2.1 49.66,21.14 v1(49.66,21.84)
VDD_CORE: length 33.9
  TOP w0.305: U5.F7 v1(51.93,31.09) ; U5.L7 v1(51.13,35.09) U5.K8 ; U5.G6 v1(52.73,31.89) U5.F6 ; U5.H11 v1(47.93,32.69) ; v1(50.33,35.89) U5.L9 ; U5.K6 v1(52.73,35.09) U5.L6 ; U5.J12 v1(47.13,33.49) ; v1(51.93,31.89) U5.G7 ; v1(48.73,32.69) U5.G10 ; U5.M13 v1(46.33,36.69) ; v1(47.93,35.09) U5.K12 ; U5.N9 v1(50.33,37.49) U5.N8 ; U5.M11 v1(48.73,35.89) ; v1(51.13,35.89) U5.L8 ; U5.N13 v1(47.13,36.69) U5.N12 ; v1(53.53,36.69) U5.M5
  TOP w0.508: 36.7,20.32 36.7,18.54 TP17.1 R13.2 ; 36.7,20.32 v1(37.21,20.32) ; 36.7,20.32 v1(36.2,20.32)
  BOTTOM w0.305: v1(43.93,35.89) 43.64,35.89 42.74,34.99 42.54,34.99 C36.1 ; v1(47.93,35.09) 47.42,34.58 C37.1 47.42,33.78 v1(47.13,33.49) v1(47.93,32.69) ; C34.1 49.64,37.89 49.93,37.89 v1(50.33,37.49) ; C39.1 50.73,34.4 U5.K8 v1(51.13,35.09) v1(52.73,35.09) ; v1(50.33,35.89) 49.64,35.89 C38.1 49.42,35.89 v1(48.73,35.89) ; v1(47.13,36.69) v1(46.33,36.69) 46.33,37.38 C33.1 ; C35.1 v1(51.13,35.89) ; C40.1 48.84,32.58 v1(48.73,32.69) ; v1(52.73,31.89) v1(51.93,31.89) v1(51.93,31.09) 51.24,31.09 C41.1
  BOTTOM w0.381: C49.1 C48.1 v1(43.13,31.89)
  vias: v1(38.99,32.77) v1(38.99,32) v1(38.99,30.48)
VDD_FTREGIN: length 3.5
  TOP w0.305: v1(38.1,16.51) 38.17,16.58 U12.50
  BOTTOM w0.381: v1(38.1,16.51) 38.41,16.82 FB8.2
VDD_FTVPHY: length 4.7
  TOP w0.305: v1(43.18,9.53) 42.84,9.18 U12.4
  BOTTOM w0.381: C158.1 42.86,9.21 v1(43.18,9.53) FB7.2
VDD_FTVPLL: length 4.5
  TOP w0.305: U12.9 45.33,9.46 v1(45.4,9.53)
  BOTTOM w0.381: FB6.2 v1(45.4,9.53) C161.1
VDD_LED: length 8.3
  TOP w0.381: R99.1 R98.1 R97.1 ; R97.1 FB4.1 11.24,47.11 C100.1 ; R97.1 R96.1
VDD_MPU: length 32.7
  TOP w0.305: U5.F10 v1(48.73,31.89) U5.F11 U5.F12 v1(47.13,31.09) U5.F13 v1(46.33,31.89) U5.G13 46.62,32.4 46.62,32.98 U5.H13 v1(46.33,33.49) U5.J13
  TOP w0.508: v1(36.2,13.08) v1(35.43,13.08) 33.15,13.08 32.51,12.45 R204.2
  BOTTOM w0.203: v1(48.73,31.89) 48.73,31.71 48,30.98 C45.1
  BOTTOM w0.305: C45.1 47.24,30.98 v1(47.13,31.09)
  BOTTOM w0.381: v1(46.33,33.49) 46.44,33.6 C47.1 ; C46.1 40.51,21.34
  BOTTOM w0.762: v1(40.51,26.16) 40.89,26.16 41.15,25.91 C44.2 41.15,23.62 40.51,22.99 40.51,21.34 40.39,21.34 39.62,20.57 39.62,19.94 37.08,17.4 37.08,13.97 v1(36.2,13.08) v1(35.43,13.08) 33.97,13.08
VDD_MPUON: length 2.9
  TOP w0.121: TP5.1 56.26,25.65 56.26,26.16 55.88,26.54 55.88,27.14 U5.A2
VDD_PHYA: length 16.9
  TOP w0.254: v1(23.94,28.96) 24.28,29.3 U15.1 ; U15.27 22.95,33.14 22.73,33.35 22.73,33.53 22.23,34.04 v1(22.23,34.29)
  BOTTOM w0.381: R142.2 v1(10.67,29.21) ; C120.1 C121.1 23.5,33.02 v1(22.23,34.29) 22.75,34.82 22.75,36.09 23.88,37.21 FB5.2 ; R134.2 v1(19.68,33.34) ; R130.2 v1(19.68,31.43) ; R133.2 v1(19.68,32.38) ; R129.2 v1(19.68,30.48) ; C119.1 v1(23.94,28.96)
VDD_PLL: length 15.1
  TOP w0.305: v1(47.93,38.29) U5.R11 v1(48.73,39.09) 49.13,38.7 U5.R10 ; U5.H15 v1(44.73,32.69)
  LYR3 w0.381: v1(48.73,39.09) v1(47.93,38.29) 47.1,37.47 45.47,37.47 45.04,37.04 45.03,37.04 44.95,36.96 43.92,36.96 43.66,36.7 43.66,36.47 43.32,36.13 42.89,36.13 v1(42.33,36.69)
  BOTTOM w0.305: C88.1 v1(47.93,38.29)
  BOTTOM w0.635: FB1.2 39.37,37.78 39.37,37.34 40.02,36.69 v1(42.33,36.69)
VDD_RTC: length 5.3
  TOP w0.305: v1(52.73,29.49) U5.D6
  BOTTOM w0.121: C97.1 52.64,25.65 52.64,26.48 52.83,26.67 52.83,28.23 53.13,28.52 53.13,28.62 53.13,29.09 v1(52.73,29.49)
VDDS_DDR: length 121.9
  TOP w0.305: U5.E5 v1(53.53,30.29) ; U6.C1 v1(68.33,38.69) ; v1(75.53,37.09) 75.53,37.09 U6.E9 ; U5.F5 v1(53.53,31.89) U5.G5 ; U6.C3 v1(69.93,38.69) ; U6.G7 v1(73.93,35.49) ; U6.R1 v1(68.33,28.29) ; U5.J5 v1(53.53,33.49) U5.H5 ; U5.L5 v1(53.53,35.09) U5.K5 ; U6.G3 v1(69.93,35.49) ; U6.E1 v1(68.33,37.09) ; U6.C9 75.13,38.29 v1(75.53,37.89) ; v1(73.93,37.89) 73.53,38.29 U6.C7 ; U6.J1 v1(68.33,33.09) ; U6.A1 v1(68.33,40.29) ; v1(75.53,40.29) 75.53,40.29 U6.A9 ; U6.G9 75.53,35.49 v1(75.53,35.49) ; 75.53,30.69 U6.M9 ; 75.53,33.09 U6.J9 ; U6.G1 v1(68.33,35.49)
  TOP w0.381: TP18.1 77.43,28.45 C117.1 C115.1 v1(76.71,30.69) 75.53,30.69 75.53,30.69 ; C109.1 v1(75.53,40.29) ; 75.53,33.09 v1(76.71,33.09) C113.1 C114.1 ; C89.2 v1(75.88,42.55) ; C112.1 v1(75.53,35.49) ; C116.1 v1(68.39,42.55) ; C111.1 v1(75.53,37.09) ; C110.1 76.33,38.69 v1(75.53,37.89)
  LYR3 w0.381: v1(71.75,8.26) 71.75,3.81 71.12,3.17 21.46,3.17 20.95,3.68 20.95,5.65 v1(21.27,5.97)
  LYR4 w0.381: v1(69.34,23.62) 68.45,22.73 68.45,11.56 v1(71.75,8.26)
  BOTTOM w0.305: v1(53.53,35.09) 53.53,35.78 C90.1 ; C93.1 53.53,30.98 v1(53.53,30.29) ; v1(53.53,33.49) 53.53,34.18 C91.1 ; v1(53.53,31.89) 53.53,32.58 C92.1
  BOTTOM w0.381: C104.1 v1(68.33,38.69) ; C103.1 v1(68.33,40.29) ; R74.1 v1(64.01,32.7) ; C105.1 v1(68.33,37.09) ; C106.1 v1(68.33,35.49) ; C108.1 v1(68.33,28.29) ; C107.1 v1(68.33,33.09) ; R14.2 21.84,6.54 v1(21.27,5.97) ; C96.1 C91.1 ; C95.1 v1(68.39,42.55) ; C94.1 v1(75.88,42.55)
AIN0: length 34.4
  TOP w0.121: v1(53.21,20.32) 52.7,20.32 52.29,20.74 52.29,21.55 52.46,21.72 52.46,25.2 52.32,25.33 52.32,26.85 51.93,27.24 51.93,27.89 U5.B6
  LYR4 w0.133: v1(53.21,20.32) 53.59,20.32 56.77,17.14 56.77,13.84 64.64,5.97 65.66,5.97 66.67,4.95 66.67,3.17 P9.39
AIN1: length 32.9
  TOP w0.121: v1(51.93,28.69) U5.C7
  LYR4 w0.133: P9.40 66.17,6.22 64.77,6.22 57.02,13.97 57.02,17.27 53.52,20.78 52.38,20.78 51.93,21.22 v1(51.93,28.69)
AIN2: length 33.1
  TOP w0.121: v1(53.21,19.05) 51.79,20.47 51.79,21.89 51.96,22.06 51.96,24.99 51.82,25.14 51.82,26.59 51.13,27.28 51.13,27.89 U5.B7
  LYR4 w0.133: v1(53.21,19.05) 54.1,19.05 56.26,16.89 56.26,13.59 64.39,5.46 64.39,2.92 P9.37
AIN3: length 29.5
  TOP w0.121: U5.A7 51.53,27.26 52.07,26.72 52.07,25.24 52.21,25.1 52.21,21.95 52.04,21.78 52.04,20.6 52.96,19.68 v1(53.21,19.68)
  LYR4 w0.133: P9.38 65.41,4.83 56.52,13.72 56.52,17.02 53.85,19.68 v1(53.21,19.68)
AIN4: length 32.5
  TOP w0.121: v1(51.13,28.69) U5.C8
  LYR4 w0.133: v1(51.13,28.69) 51.56,28.26 51.56,21.08 52.81,19.84 52.81,17.61 53.15,17.27 53.72,17.27 55.5,15.49 55.5,12.19 61.59,6.1 61.59,3.17 P9.33
AIN5: length 30.8
  TOP w0.121: U5.B8 50.33,27.89 50.33,27.14 50.67,26.8 50.67,25.53 51.47,24.73 51.47,22.26 51.3,22.09 51.3,19.69 v1(53.21,17.78)
  LYR4 w0.133: P9.36 62.87,6.22 60.45,8.64 59.44,8.64 58.8,9.27 58.8,10.29 55.75,13.34 55.75,16.64 54.61,17.78 v1(53.21,17.78)
AIN6: length 32.9
  TOP w0.121: U5.A8 50.73,27.25 51.56,26.42 51.56,25.04 51.71,24.89 51.71,22.16 51.55,21.99 51.55,20.08 v1(53.21,18.41)
  LYR4 w0.133: v1(53.21,18.41) 54.36,18.41 56.01,16.76 56.01,13.46 59.05,10.41 59.05,9.4 59.56,8.89 60.58,8.89 63.88,5.59 63.88,2.92 P9.35
AIN7: length 28.9
  TOP w0.121: v1(50.33,28.69) U5.C9
  LYR3 w0.133: v1(28.26,23.81) 28.83,23.24 30.35,23.24 30.67,23.56 30.67,24 30.92,24.26 32.26,24.26 32.51,24.51 33.4,24.51 33.66,24.26 35.43,24.26 36.32,25.15 38.35,25.15 38.86,25.65 49.91,25.65 50.33,26.07 v1(50.33,28.69)
  BOTTOM w0.121: v1(28.26,23.81) R9.2 R8.1
BAT: length 25.1
  TOP w0.121: 21.46,17.27 21.63,17.11 U2.5 ; 21.46,17.27 21.68,17.49 22.31,17.49 U2.4 ; 21.46,17.27 19.43,17.27 18.92,17.78 16.64,17.78 15.88,17.02 15.88,15.88 15.49,15.49 11.43,15.49 10.79,16.13 10.79,16.89 10.16,17.53 8,17.53 P6.1
  LYR3 w0.133: P6.2 P6.1
  BOTTOM w0.121: C3.2 7.37,15.11 6.99,15.49 P6.1
BAT_SENSE: length 14
  TOP w0.121: U2.6 21.03,16.71 20.57,16.26 18.41,16.26 17.27,15.11 10.92,15.11 P6.3
BAT_TEMP: length 16.5
  TOP w0.121: U2.11 21.82,14.71 21.46,14.35 v1(21.46,13.97)
  LYR3 w0.133: v1(21.46,13.97) 12.7,13.97 10.79,15.88 10.79,17.78 P6.4
BL_IN: length 17.9
  TOP w0.121: P6.8 15.88,20.32 18.54,20.32 20.32,22.1 27.18,22.1 28.7,20.57 28.7,19.94 28.35,19.58 U2.37
BL_ISET1: length 22.5
  TOP w0.121: U2.35 28.98,18.31 29.21,18.54 29.21,20.83 27.43,22.61 20.07,22.61 18.29,20.83 13.84,20.83 12.06,19.05
BL_ISET2: length 23.2
  TOP w0.121: U2.36 28.47,19.18 28.96,19.66 28.96,20.7 27.3,22.35 20.19,22.35 19.81,21.96 19.79,21.96 19.27,21.44 19.27,21.42 18.41,20.57 14.48,20.57 13.34,19.43 13.34,17.78 12.06,16.51
BL_OUT: length 21.4
  TOP w0.121: P6.7 15.75,17.65 15.75,19.3 16.51,20.07 18.67,20.07 20.45,21.84 26.42,21.84 27.22,21.04 27.22,19.6 U2.38
  BOTTOM w0.121: C7.1 13.97,13.97 14.61,14.61 P6.7
BL_SINK1: length 22.2
  TOP w0.121: U2.34 29.09,17.91 29.46,18.29 29.46,20.95 27.56,22.86 19.56,22.86 v1(18.03,21.34)
  LYR3 w0.133: v1(18.03,21.34) 18.41,20.95 18.41,17.78 P6.9
BL_SINK2: length 20.9
  TOP w0.121: U2.33 29.07,17.51 29.72,18.16 29.72,21.08 27.69,23.11 18.92,23.11 v1(17.14,21.34)
  LYR3 w0.133: v1(17.14,21.34) P6.10
CAP_VBB_MPU: length 4.1
  TOP w0.121: U5.C10 48.74,28.7 v1(48.73,28.69)
  BOTTOM w0.121: v1(48.73,28.69) 48.73,26.33 48.9,26.16 C85.1
CAP_VDD_SRAM_CORE: length 5.2
  TOP w0.121: v1(50.33,29.49) U5.D9
  BOTTOM w0.121: v1(50.33,29.49) 50.73,29.09 50.73,28.25 50.16,27.69 C83.1
CAP_VDD_SRAM_MPU: length 5.1
  TOP w0.121: v1(47.93,29.49) U5.D11
  BOTTOM w0.121: v1(47.93,29.49) 47.53,29.09 47.53,28.42 47.94,28 C84.1
CD/EMU4: length 35.1
  TOP w0.121: v1(44.73,28.69) U5.C15
  LYR3 w0.133: v1(62.36,19.05) 64.64,21.34 v1(66.04,21.34)
  BOTTOM w0.121: v1(66.04,21.34) 68.33,21.34 69.34,20.32 R197.2 ; v1(44.73,28.69) 45.21,28.21 45.21,23.88 45.97,23.11 51.44,23.11 53.72,20.83 58.67,20.83 59.56,19.94 59.56,18.8 59.94,18.41 R185.1 60.45,18.8 60.71,19.05 v1(62.36,19.05)
CLKOUT2: length 49.9
  TOP w0.121: v1(45.53,29.49) U5.D14
  LYR4 w0.133: P9.41 69.22,3.17 69.22,5.71 66.04,8.89 v1(66.04,20.32)
  BOTTOM w0.121: v1(45.53,29.49) 45.57,29.49 45.93,29.13 45.93,28.45 45.47,27.98 45.47,24.13 46.23,23.37 51.56,23.37 53.85,21.08 58.67,21.08 59.18,21.59 64.26,21.59 65.53,20.32 v1(66.04,20.32) R184.2
COL/CRS_DV/MODE2: length 3.3
  TOP w0.121: R207.2 30.45,34.77 29.81,34.77 29.46,34.42 29.46,34.04 29.06,33.64 U15.15
CRFILT: length 2.3
  TOP w0.121: C146.1 24.26,40.01 23.99,40.28 U11.9
CRS_DV/MODE2: length 7.7
  TOP w0.121: U15.14 29.2,33.14 30.1,34.04 v1(30.1,34.29) R139.2
  BOTTOM w0.121: R127.1 33.94,34.77 31.4,34.77 R139.2 v1(30.1,34.29)
DC_IN: length 1.8
  TOP w0.203: U2.10 21.46,15.11
  BOTTOM w0.381: v1(16.76,11.68) 16.64,11.56 C1.1
DDR_A0: length 26.8
  TOP w0.121: v1(62.23,28.45) 63.75,28.45 63.88,28.57 63.88,32.13 64.01,32.26 67.31,32.26 67.44,32.13 67.44,27.69 67.56,27.56 70.48,27.56 71.12,28.19 71.12,31.36 71.25,31.49 73.93,31.49 U6.M8
  BOTTOM w0.121: R29.1 61.79,28.89 v1(62.23,28.45)
DDR_A1: length 26.9
  TOP w0.121: U6.M3 v1(69.93,30.69) ; R25.1 v1(62.23,31.75)
  LYR3 w0.121: 68.58,31.89 69.3,31.89 69.53,31.66 69.53,31.09 v1(69.93,30.69)
  LYR3 w0.133: v1(62.23,31.75) 62.23,31.24 62.36,31.11 63.5,31.11 63.63,30.99 63.63,28.19 63.5,28.07 62.61,28.07 62.48,27.94 62.48,24.38 62.61,24.26 63.5,24.26 63.63,24.38 63.63,26.67 63.75,26.8 65.66,26.8 65.79,26.92 65.79,31.76 65.91,31.89 68.16,31.89 68.16,31.9 68.5,31.9 68.51,31.89 68.58,31.89
DDR_A2: length 27.2
  TOP w0.121: v1(62.99,27.56) 63.25,27.56 64.14,28.45 64.14,31.88 64.26,32 67.06,32 67.18,31.88 67.18,27.43 67.31,27.3 70.64,27.3 72.14,28.8 72.14,29.34 72.01,29.46 71.5,29.46 71.37,29.59 71.37,30.96 71.5,31.09 U6.M7
  BOTTOM w0.121: R30.1 60.2,26.04 60.71,26.54 61.98,26.54 v1(62.99,27.56)
DDR_A3: length 27.2
  TOP w0.121: U6.N2 v1(69.13,29.89)
  BOTTOM w0.121: R26.1 57.28,24.26 57.4,24.13 57.4,23.88 57.53,23.75 65.02,23.75 65.15,23.88 65.15,24 65.02,24.13 62.23,24.13 62.1,24.26 62.1,24.51 62.23,24.64 67.69,24.64 67.82,24.77 67.82,26.67 67.94,26.8 69.98,26.8 70.1,26.92 70.1,27.3 69.98,27.43 69.66,27.43 69.53,27.56 69.53,28.45 69.3,28.69 68.85,28.69 68.65,28.89 68.65,29.15 68.73,29.24 68.73,29.25 69.13,29.65 v1(69.13,29.89)
DDR_A4: length 27
  TOP w0.121: U6.N8 v1(74.73,29.89) ; R31.1 61.66,22.67 63.52,24.53 66.78,24.53 67.18,24.13 68.83,24.13 v1(69.34,24.64)
  LYR3 w0.133: v1(74.73,29.89) 74.73,30.61 74.86,30.73 76.07,30.73 76.2,30.61 76.2,28.32 76.07,28.19 74.93,28.19 74.8,28.32 74.8,28.83 74.68,28.96 73.53,28.96 72.01,27.43 71.5,27.43 70.99,26.92 70.99,25.53 70.1,24.64 v1(69.34,24.64)
DDR_A5: length 27.3
  TOP w0.121: U6.N3 v1(69.93,29.89) ; v1(67.31,23.62) 66.65,24.29 63.66,24.29 61.47,22.1 58.36,22.1 R32.1
  LYR3 w0.121: 69.53,28.07 69.53,29.49 v1(69.93,29.89)
  LYR3 w0.133: v1(67.31,23.62) 67.44,23.75 67.44,26.42 67.31,26.54 66.67,26.54 66.55,26.67 66.55,30.73 66.67,30.86 67.44,30.86 67.56,30.73 67.56,28.19 67.94,27.81 69.28,27.81 69.53,28.07
DDR_A6: length 27.2
  TOP w0.121: U6.N7 v1(73.93,29.89)
  LYR3 w0.133: v1(73.93,29.89) 73.93,30.61 73.81,30.73 73.15,30.73 73.03,30.61 73.03,28.83 71.88,27.69 71.37,27.69 70.36,26.67 v1(70.36,26.04)
  BOTTOM w0.121: v1(70.36,26.04) 70.74,25.65 70.74,24.26 69.7,23.22 55.39,23.22 54.93,23.69 R33.1
DDR_A7: length 26.8
  TOP w0.121: R34.1 61.72,26.04 61.85,25.91 v1(66.8,25.91) ; U6.P2 v1(69.13,29.09)
  LYR3 w0.133: v1(66.8,25.91) 66.8,24.26 66.67,24.13 64.39,24.13 64.26,24.26 64.26,26.04 64.39,26.16 64.77,26.16 64.9,26.04 64.9,24.77 65.02,24.64 66.17,24.64 66.29,24.77 66.29,30.99 66.42,31.11 67.69,31.11 67.82,30.99 67.82,29.22 67.94,29.09 v1(69.13,29.09)
DDR_A8: length 27.2
  TOP w0.121: U6.P8 74.52,29.49 75.06,28.96 75.06,27.81 74.55,27.3 71.37,27.3 70.87,26.8 66.93,26.8 66.68,27.05 66.68,30.48 66.55,30.61 64.9,30.61 64.77,30.48 64.77,27.94 64.9,27.81 65.28,27.81 65.41,27.69 65.41,26.8 65.28,26.67 v1(62.99,26.67)
  BOTTOM w0.121: v1(62.99,26.67) 62.36,26.04 61.09,26.04 60.13,25.08 R35.1
DDR_A9: length 27.3
  TOP w0.121: R36.1 61.79,23.18 63.39,24.78 68.18,24.78 v1(68.33,24.64) ; U6.P3 v1(69.93,29.09)
  LYR3 w0.133: v1(68.33,24.64) 68.33,25.15 68.83,25.65 68.83,26.8 68.71,26.92 68.45,26.92 68.33,26.8 68.33,25.91 68.2,25.78 67.94,25.78 67.82,25.91 67.82,26.8 67.69,26.92 66.93,26.92 66.8,27.05 66.8,30.48 66.93,30.61 67.18,30.61 67.31,30.48 67.31,27.43 67.44,27.3 69.77,27.3 70.61,28.15 70.61,28.96 70.48,29.09 v1(69.93,29.09)
DDR_A10: length 27.2
  TOP w0.121: U6.M2 v1(69.13,30.69)
  BOTTOM w0.121: v1(69.13,30.69) 69.13,30.45 68.73,30.06 68.73,29.72 67.97,28.96 64.9,28.96 64.77,28.83 64.77,27.56 64.9,27.43 67.18,27.43 67.31,27.3 67.31,27.05 67.18,26.92 66.55,26.92 66.42,26.8 66.42,26.54 66.55,26.42 67.18,26.42 67.31,26.29 67.31,25.27 67.18,25.15 63.88,25.15 63.75,25.27 63.75,28.19 63.63,28.31 62.76,28.31 61.75,27.3 61.34,27.3 61.21,27.43 61.21,28.32 61.09,28.45 60.83,28.45 60.71,28.32 60.71,27.43 60.58,27.3 60.33,27.3 60.2,27.43 60.2,27.81 60.07,27.94 R37.1
DDR_A11: length 27.1
  TOP w0.121: U6.P7 73.77,29.49 74.17,29.09 74.5,29.09 74.8,28.78 74.8,28.07 74.34,27.61 71.33,27.61 70.77,27.05 67.06,27.05 66.93,27.18 66.93,31.62 66.8,31.75 64.52,31.75 64.39,31.62 64.39,28.04 64.39,27.69 64.52,27.56 64.9,27.56 65.02,27.43 65.02,27.05 64.9,26.92 63.54,26.92 63.32,27.14 62.52,27.14 61.72,27.94 R38.1
DDR_A12: length 27.1
  TOP w0.121: U6.R2 v1(69.13,28.29)
  BOTTOM w0.121: v1(69.13,28.29) 69.13,27.18 69.01,27.05 68.58,27.05 68.45,27.18 68.45,27.56 68.33,27.69 67.69,27.69 67.56,27.56 67.56,25.02 67.44,24.89 61.98,24.89 61.85,24.77 61.85,24.13 61.72,24 59.69,24 59.56,24.13 59.56,24.38 59.69,24.51 61.21,24.51 61.34,24.64 61.34,25.27 61.47,25.4 63.37,25.4 63.5,25.53 63.5,27.94 63.37,28.07 62.87,28.07 61.79,26.99 R39.1
DDR_A13: length 27.1
  BOTTOM w0.121: R120.1 66.22,30.23 66.35,30.1 67.31,30.1 67.44,29.97 67.44,29.72 67.31,29.59 65.41,29.59 65.28,29.72 65.28,32.13 64.88,32.53 64.88,33.4 64.75,33.53 64.53,33.53 64.41,33.4 64.41,32.49 64.77,32.13 64.77,29.72 64.64,29.59 64.39,29.59 64.26,29.72 64.26,32 64.14,32.13 63.88,32.13 63.75,32 63.75,30.82 63.63,30.69 63.37,30.69 63.25,30.82 63.25,31.24 63.14,31.35 62.87,31.35 62.74,31.22 62.74,30.82 62.61,30.69 62.36,30.69 62.23,30.82 62.23,31.24 62.1,31.37 61.85,31.37 61.72,31.24 61.72,30.82 61.59,30.69 61.34,30.69 61.21,30.82 61.21,32 61.09,32.13 60.83,32.13 60.71,32 60.71,30.82 60.58,30.69 60.33,30.69 60.2,30.82 60.2,31.62 60.07,31.75 R40.1
DDR_A13R: length 7.9
  TOP w0.121: v1(72.07,30.29) 73.27,29.09 73.7,29.09 74.1,28.69 U6.R8
  LYR3 w0.121: v1(68.33,30.69) 68.73,30.29 70.17,30.29
  LYR3 w0.133: v1(72.07,30.29) 70.17,30.29
  BOTTOM w0.121: R120.2 v1(68.33,30.69)
DDR_BA0: length 26.9
  TOP w0.121: U6.L2 v1(69.13,31.49)
  BOTTOM w0.121: R41.1 55.88,23.75 56.13,23.5 65.41,23.5 65.53,23.62 65.53,23.89 65.66,24.02 69.74,24.02 70.36,24.64 70.36,25.15 70.23,25.27 68.83,25.27 68.71,25.4 68.71,26.42 68.83,26.54 70.23,26.54 70.36,26.67 70.36,28.45 70.12,28.69 69.77,28.69 69.53,28.92 69.53,31.09 v1(69.13,31.49)
DDR_BA1: length 26.9
  TOP w0.121: v1(69.34,26.04) 68.96,26.42 66.42,26.42 66.29,26.54 66.29,30.1 66.17,30.23 65.53,30.23 65.41,30.1 65.41,28.96 65.53,28.83 65.66,28.83 65.79,28.7 65.79,26.29 65.66,26.16 62.61,26.16 61.79,26.99 R42.1 ; U6.L3 v1(69.93,31.49)
  LYR3 w0.133: v1(69.93,31.49) 71.76,31.49 72.52,30.73 72.52,29.21 71.5,28.19 70.99,28.19 69.87,27.07 69.47,27.07 69.34,26.94 v1(69.34,26.04)
DDR_BA2: length 27.1
  TOP w0.121: U6.L1 v1(68.33,31.49) ; v1(66.04,23.62) 63.75,23.62 61.72,21.59 56.96,21.59 R43.1
  LYR3 w0.133: v1(66.04,23.62) 64.01,23.62 63.88,23.75 63.88,26.42 64.01,26.54 65.15,26.54 65.28,26.42 65.28,26.16 65.41,26.04 65.91,26.04 66.04,26.16 66.04,31.36 66.17,31.49 v1(68.33,31.49)
DDR_CASN: length 26.9
  TOP w0.121: U6.L7 73.03,32.4 70.99,32.4 70.87,32.27 70.87,28.32 70.36,27.81 67.82,27.81 67.69,27.94 67.69,33.53 67.56,33.66 64.77,33.66 64.64,33.53 64.64,33.37 64.52,33.24 63.66,33.24 63.54,33.11 63.54,29.08 63.41,28.96 61.21,28.96 R64.1
DDR_CKE: length 27.1
  TOP w0.121: U6.K2 v1(69.13,32.29)
  BOTTOM w0.121: v1(69.13,32.29) 68.73,31.89 68.73,30.52 68.5,30.29 68.29,30.29 68.07,30.29 67.82,30.04 67.82,29.46 67.56,29.21 64.64,29.21 64.52,29.08 64.52,27.18 64.64,27.05 65.66,27.05 65.79,26.92 65.79,25.53 65.66,25.4 65.28,25.4 65.15,25.53 65.15,26.54 65.02,26.67 64.77,26.67 64.64,26.54 64.64,25.53 64.52,25.4 64.26,25.4 64.14,25.53 64.14,28.57 64.01,28.7 63.12,28.7 62.99,28.83 62.99,29.08 63.12,29.21 63.63,29.21 63.75,29.34 63.75,30.23 63.63,30.35 60.01,30.35 R62.1
DDR_CLK: length 27.1
  TOP w0.095: R60.1 61.49,24.47 62.06,24.47 62.74,25.15 70.74,25.15 v1(71.63,26.04)
  TOP w0.121: v1(74.73,33.09) 74.33,33.49 U6.J8
  LYR3 w0.102: v1(71.63,26.04) 72.31,26.04 73.66,27.38 77.6,27.38 78.16,27.94 78.16,31.95 77.57,32.54 76.48,32.54 75.93,33.09 v1(74.73,33.09)
DDR_CLKN: length 27
  TOP w0.095: v1(71.63,26.67) 71.35,26.67 71.22,26.54 71.22,26.03 70.62,25.43 62.62,25.43 61.94,24.75 61.49,24.75 R61.1
  TOP w0.121: v1(74.73,32.29) 74.33,32.69 U6.K8
  LYR3 w0.102: v1(74.73,32.29) 74.73,32.54 74.98,32.79 75.8,32.79 76.35,32.23 77.45,32.23 77.85,31.83 77.85,28.07 77.47,27.69 73.53,27.69 72.19,26.34 71.96,26.34 v1(71.63,26.67)
DDR_CSN: length 26.9
  TOP w0.121: R63.1 62.17,30.8 v1(63.12,31.75) ; U6.L8 74.33,31.89 v1(74.73,31.49)
  LYR3 w0.133: v1(74.73,31.49) 73.53,31.49 73.41,31.62 73.41,31.88 73.28,32 71.37,32 71.25,32.13 71.25,33.4 71.12,33.53 67.94,33.53 67.82,33.4 67.82,32.26 67.69,32.13 65.53,32.13 65.41,32 65.41,29.46 65.28,29.34 64.77,29.34 64.64,29.21 64.64,27.18 64.52,27.05 64.14,27.05 64.01,27.18 64.01,31.62 63.88,31.75 v1(63.12,31.75)
DDR_D0: length 27.2
  TOP w0.121: v1(74.73,35.49) 74.33,35.09 U6.G8
  LYR3 w0.121: v1(74.73,35.49) 74.33,35.89 73.66,35.89
  LYR3 w0.133: v1(62.23,36.96) 61.72,37.47 61.72,38.48 64.52,41.27 65.02,41.27 65.91,42.16 67.31,42.16 67.94,41.53 70.1,41.53 72.39,39.24 72.39,34.54 72.64,34.29 73.15,34.29 73.4,34.54 73.4,35.63 73.66,35.89
  BOTTOM w0.121: R44.1 60.13,36.51 60.58,36.96 v1(62.23,36.96)

# Allegro board BEAGLEBONE_REVC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PMIC_INT_PU: length 4.6
  TOP w0.121: U14.7 33.66,26.28 33.53,26.41 33.53,27.59 33.66,27.72 34.51,27.72 v1(34.92,27.3)
  BOTTOM w0.121: R28.1 v1(34.92,27.3)
PMIC_INT_SRC: length 17.5
  TOP w0.121: v1(30.16,21.21) 29.69,21.68 29.69,25.37 30.61,26.29 ; 30.61,26.29 30.61,26.67 30.72,26.78 U14.1 ; 30.61,26.29 31.54,26.29 U14.2 ; U2.45 24.4,20.08 24.51,20.19 24.51,20.83 v1(24.38,20.95)
  LYR3 w0.133: v1(30.16,21.21) 29.65,21.72 25.15,21.72 v1(24.38,20.95)
  BOTTOM w0.121: v1(30.16,21.21) R203.2 R10.1
PMIC_PGOOD: length 35
  TOP w0.121: v1(29.72,13.46) 29.1,14.08 29.1,14.57 28.96,14.71 U2.26 ; v1(44.73,27.89) U5.B15
  LYR3 w0.121: 43.76,27.49 44.33,27.49 v1(44.73,27.89)
  LYR3 w0.133: v1(29.21,24.77) 29.21,25.15 29.72,25.65 37.85,25.65 38.35,26.16 38.81,26.16 40.13,27.49 43.76,27.49
  LYR4 w0.133: v1(29.72,13.46) 30.63,14.38 30.63,24.99 30.35,25.27 29.72,25.27 v1(29.21,24.77)
  BOTTOM w0.121: v1(29.21,24.77) R20.1 C25.1
PMIC_POWR_EN: length 47.9
  TOP w0.121: v1(19.18,15.75) 21.13,15.75 21.37,15.51 U2.9 ; v1(52.73,28.69) U5.C6
  LYR3 w0.133: v1(52.7,21.21) 52.58,21.08 35.56,21.08 31.11,16.64 28.57,16.64 27.94,17.27 20.7,17.27 v1(19.18,15.75)
  LYR4 w0.133: v1(52.73,28.69) 52.32,28.28 52.32,21.59 v1(52.7,21.21)
PWR_BUT: length 14.1
  TOP w0.121: U2.25 28.47,13.88 v1(29.72,12.64)
  LYR4 w0.133: P9.9 28.7,3.05 28.7,12.19 29.15,12.64 v1(29.72,12.64)
PWR_LED: length 21.2
  TOP w0.121: U2.1 22.33,19.46 v1(21.46,20.32)
  BOTTOM w0.121: v1(21.46,20.32) 20.95,20.83 19.3,20.83 18.8,20.32 18.8,18.8 17.78,17.78 5.84,17.78 5.4,17.34 R6.1
PWR_LEDR: length 4
  TOP w0.121: v1(5.59,15.56) D1.2 4.64,17.02 TP14.1
  BOTTOM w0.121: R6.2 5.27,16.32 5.59,16 v1(5.59,15.56)
RBIAS: length 2.7
  TOP w0.121: U15.32 23.01,30.63 22.86,30.48 22.86,30.16 v1(22.23,29.53)
  BOTTOM w0.121: v1(22.23,29.53) 21.46,29.53
REFCLKO: length 5.2
  TOP w0.121: R209.2 v1(30.1,28.57) 29.59,29.08 27.69,29.08 27.29,29.48 U15.7
  BOTTOM w0.121: R209.2 v1(30.1,28.57)
RESETN: length 3.8
  TOP w0.121: 20.95,45.85 22.23,45.85 22.23,45.34 21.46,44.57 U11.17
RMII1_COL: length 23.4
  TOP w0.121: v1(32.64,35.81) 32.07,35.24 R207.1 ; v1(43.93,32.69) U5.H16
  LYR3 w0.133: v1(43.93,32.69) 43.47,33.15 39.75,33.15 39.62,33.27 38.48,33.27 v1(37.97,32.77)
  BOTTOM w0.121: v1(32.64,35.81) 30.83,35.81 30.61,35.59 30.61,35.28 30.83,35.05 34.29,35.05 34.54,35.31 34.54,36.07 34.8,36.32 35.43,36.32 36.2,35.56 36.2,33.02 36.96,32.26 36.96,31.88 37.21,31.62 37.72,31.62 37.97,31.88 v1(37.97,32.77)
RMII1_CRS_DV: length 23.1
  TOP w0.121: v1(33.66,32.38) 33.66,33.02 32.89,33.78 32.45,33.78 R139.1 ; U5.H17 43.13,33.49 41.53,33.49 41.31,33.27 36.7,33.27 36.45,33.02 v1(36.45,32)
  LYR3 w0.133: v1(36.45,32) 37.97,32 38.1,31.88 38.1,31.37 37.97,31.24 34.29,31.24 34.16,31.37 34.16,31.75 34.29,31.88 35.69,31.88 35.81,32 35.81,32.89 35.69,33.02 35.18,33.02 34.54,32.38 v1(33.66,32.38)
RMII1_REFCLK: length 20.8
  TOP w0.121: R201.2 37.21,31.37 v1(37.21,30.48) ; R209.1 v1(32.64,28.57)
  LYR3 w0.133: v1(32.64,28.57) 33.4,27.81 36.58,27.81 36.7,27.94 36.7,28.19 36.58,28.32 34.29,28.32 34.16,28.45 34.16,28.7 34.29,28.83 36.58,28.83 36.7,28.96 36.7,29.21 36.58,29.34 33.78,29.34 33.66,29.46 33.66,29.72 33.78,29.84 36.58,29.84 v1(37.21,30.48)
  BOTTOM w0.121: v1(32.64,28.57) 32.64,28.83 R200.1
RMII1_RXCLK: length 20.2
  TOP w0.121: U5.L18 42.69,35.45 41.64,35.45 40.77,36.32 39.24,36.32 38.73,35.81 v1(37.97,35.81)
  LYR4 w0.133: v1(37.97,35.81) 37.47,35.31 36.07,35.31 35.94,35.18 35.94,34.16 35.81,34.04 35.43,34.04 35.31,34.16 35.31,35.18 35.18,35.31 34.92,35.31 34.8,35.18 34.8,29.72 v1(33.66,28.57)
  BOTTOM w0.121: v1(33.66,28.57) 33.21,28.13 32.38,28.13 R136.1
RMII1_RXD0: length 23.3
  TOP w0.121: U5.M16 43.93,36.69 v1(43.13,36.69) ; R135.1 32.45,31.88 34.04,31.88 34.29,32.13 34.29,32.89 33.15,34.04 33.15,35.31 v1(33.66,35.81)
  LYR3 w0.133: v1(33.66,35.81) 34.16,36.32 35.81,36.32 35.94,36.45 35.94,37.21 36.07,37.34 39.88,37.34 40.01,37.21 40.01,36.96 39.88,36.83 38.73,36.83 38.61,36.7 38.61,36.45 38.73,36.32 41.66,36.32 41.78,36.45 41.78,36.97 41.91,37.1 42.72,37.1 v1(43.13,36.69)
RMII1_RXD1: length 23.3
  TOP w0.121: U5.L15 v1(44.73,35.09) ; R132.1 32.83,31.43 33.27,30.99 33.91,30.99 34.16,30.73 34.16,28.83 34.29,28.7 34.54,28.7 34.67,28.83 34.67,33.91 34.29,34.29 v1(33.66,34.29)
  LYR3 w0.121: v1(44.73,35.09) 44.49,35.09 44.09,34.69 43.56,34.69
  LYR3 w0.133: v1(33.66,34.29) 34.06,34.7 43.55,34.7 43.56,34.69
RMII1_RXD2: length 23.4
  TOP w0.121: R153.1 v1(32.64,30.48) ; v1(44.73,35.89) U5.L16
  LYR4 w0.133: v1(37.97,36.83) 36.32,38.48 33.27,38.48 33.15,38.35 33.15,30.99 v1(32.64,30.48)
  BOTTOM w0.121: v1(37.97,36.83) 38.48,36.32 39.12,36.32 41.02,34.42 42.93,34.42 43.18,34.67 43.18,34.91 43.76,35.49 U5.L16 v1(44.73,35.89)
RMII1_RXD3: length 23.1
  TOP w0.121: R205.1 v1(32.64,29.53) ; v1(37.21,35.81) 37.72,35.31 41.19,35.31 41.4,35.09 43.13,35.09 43.53,35.49 U5.L17
  LYR4 w0.133: v1(37.21,35.81) 36.07,35.81 35.94,35.94 35.94,37.34 35.81,37.47 35.43,37.47 35.31,37.34 35.31,36.45 35.18,36.32 34.92,36.32 34.8,36.45 34.8,37.34 34.67,37.47 34.29,37.47 34.16,37.34 34.16,30.1 33.59,29.53 v1(32.64,29.53)
RMII1_RXDV: length 26.4
  TOP w0.121: R208.1 20.45,35.56 20.7,35.81 v1(21.34,35.81) ; U5.J17 v1(43.93,34.29)
  LYR3 w0.133: v1(43.93,34.29) 43.18,34.29 42.77,33.88 40.16,33.88 40.01,34.04 34.29,34.04 34.04,33.78 33.53,33.78 33.15,34.16 33.15,34.42 32.77,34.8 31.11,34.8 v1(30.1,35.81)
  LYR4 w0.133: v1(21.34,35.81) 21.84,36.32 29.59,36.32 v1(30.1,35.81)
RMII1_RXERR: length 23.3
  TOP w0.121: v1(44.73,34.29) U5.J15 ; R137.1 v1(32.64,33.34)
  LYR3 w0.121: v1(44.73,34.29) 44.33,33.89 43.54,33.89
  LYR3 w0.133: v1(32.64,33.34) 30.92,33.34 30.48,33.78 29.08,33.78 28.83,34.04 28.83,34.8 29.08,35.05 30.23,35.05 31.5,33.78 33.02,33.78 33.4,33.4 34.16,33.4 34.54,33.78 39.88,33.78 40.01,33.65 43.3,33.65 43.54,33.89
RMII1_TXCLK: length 23.4
  TOP w0.121: v1(35.18,37.97) 35.18,37.21 37.44,34.95 41.01,34.95 41.27,34.69 U5.K18 ; v1(31.75,37.21) 31.94,37.02 R206.1
  LYR3 w0.133: v1(35.18,37.97) 34.77,37.57 32.38,37.57 32.26,37.44 32.26,37.21 32.38,37.08 35.43,37.08 35.56,36.96 35.56,36.7 35.43,36.58 31.11,36.58 30.99,36.7 30.99,37.08 31.11,37.21 v1(31.75,37.21)
RMII1_TXD0: length 28
  TOP w0.121: v1(25.02,35.81) 25.28,35.55 U15.22 ; v1(34.42,37.97) 34.42,37.59 37.3,34.71 40.73,34.71 41.15,34.29 43.13,34.29 U5.K17
  LYR3 w0.133: v1(25.02,35.81) 25.02,36.32 24.89,36.45 23.24,36.45 23.11,36.58 23.11,38.35 23.37,38.61 33.78,38.61 v1(34.42,37.97)
RMII1_TXD1: length 28.7
  TOP w0.121: v1(24.26,35.81) 24.38,35.81 24.78,35.41 U15.23 ; v1(43.93,35.09) U5.K16
  LYR3 w0.133: v1(43.93,35.09) 43.89,35.05 31.5,35.05 29.97,36.58 27.69,36.58 26.42,37.85 24.26,37.85 24.13,37.72 24.13,37.21 24.26,37.08 25.34,37.08 25.46,36.96 25.46,35.05 25.34,34.92 24.38,34.92 24.26,35.05 v1(24.26,35.81)
RMII1_TXD2: length 29.1
  TOP w0.121: v1(45.53,35.09) U5.K15 ; v1(30.1,37.21) 30.1,36.64 29.97,36.51 26.48,36.51 26.29,36.32 24.13,36.32 23.81,36 23.81,35.62 24.28,35.15 U15.24
  LYR3 w0.121: 43.62,35.49 45.13,35.49 45.53,35.09 v1(45.53,35.09)
  LYR3 w0.133: v1(30.1,37.21) 30.1,36.83 31.62,35.31 38.35,35.31 38.48,35.43 38.48,35.81 38.61,35.94 38.86,35.94 38.99,35.81 38.99,35.43 39.12,35.31 39.37,35.31 39.5,35.43 39.5,35.81 39.62,35.94 39.88,35.94 40.01,35.81 40.01,35.43 40.13,35.31 41.02,35.31 41.15,35.43 41.15,35.81 41.27,35.94 41.53,35.94 41.66,35.81 41.66,35.43 41.78,35.31 42.04,35.31 42.16,35.43 42.16,35.56 42.29,35.69 42.55,35.69 42.67,35.56 42.67,35.43 42.8,35.31 43.43,35.31 43.62,35.49
RMII1_TXD3: length 28.4
  TOP w0.121: v1(29.34,37.21) 28.89,36.77 26.11,36.77 26.04,36.84 26.04,37.01 26.11,37.08 27.48,37.08 27.56,37.16 27.56,37.26 27.48,37.34 24.51,37.34 23.5,36.32 23.24,36.32 22.92,36 22.92,34.45 23.24,34.14 U15.25 ; U5.J18 41.15,33.89 41.04,33.78 39.88,33.78 39.37,34.29 37.34,34.29 v1(33.66,37.97)
  LYR3 w0.133: v1(33.66,37.97) 30.1,37.97 v1(29.34,37.21)
RMII1_TXEN: length 29
  TOP w0.121: v1(43.93,33.49) U5.J16 ; v1(25.91,35.81) 25.78,35.69 U15.21
  LYR3 w0.133: v1(25.91,35.81) 25.91,35.05 26.04,34.92 26.42,34.92 26.54,34.8 26.54,34.54 26.42,34.42 23.11,34.42 22.99,34.29 22.99,33.91 23.11,33.78 26.42,33.78 27.3,32.89 34.16,32.89 34.78,33.51 39.72,33.51 39.85,33.38 43.82,33.38 v1(43.93,33.49)
RSVD3: length 2.6
  TOP w0.121: 23.5,45.85 23.5,45.34 22.46,44.3 U11.15
RTC_PORZ: length 30.5
  TOP w0.121: U5.B5 v1(53.53,27.89)
  LYR3 w0.133: v1(31.11,23.81) 32.32,23.81 32.77,24.26 33.21,24.26 33.53,23.94 33.53,23.62 33.91,23.24 35.81,23.24 36.83,24.26 38.99,24.26 39.62,24.89 52.58,24.89 53.53,25.84 v1(53.53,27.89)
  BOTTOM w0.121: R18.1 31.59,25.53 ; 31.59,25.53 R141.1 ; 31.59,25.53 31.59,24.29 v1(31.11,23.81) R143.2
RTCK: length 2.8
  BOTTOM w0.121: R178.2 P7.9
RXD0/MODE0: length 8.4
  TOP w0.121: R135.2 v1(30.1,32.38) 30.1,32.13 29.6,31.63 U15.11
  LYR3 w0.133: v1(32.64,32.38) v1(30.1,32.38)
  BOTTOM w0.121: v1(30.1,32.38) R135.2 ; R198.1 33.91,32.89 33.15,32.89 v1(32.64,32.38)
RXD1/MODE1: length 7.6
  TOP w0.121: U15.10 29.8,31.13 v1(30.1,31.43) R132.2
  LYR3 w0.133: v1(33.66,31.43) v1(30.1,31.43)
  BOTTOM w0.121: R5.1 v1(33.66,31.43) ; v1(30.1,31.43) R132.2
RXD2/RMIISEL: length 7.2
  TOP w0.121: v1(33.66,30.48) 33.18,30 31.4,30 R153.2 v1(30.1,30.48) 29.21,30.48 29.06,30.63 U15.9
  BOTTOM w0.121: R212.1 v1(33.66,30.48) ; R153.2 v1(30.1,30.48)
RXD3/PHYAD2: length 10.4
  TOP w0.121: R205.2 v1(30.1,29.53) 29.91,29.34 27.91,29.34 27.79,29.46 U15.8
  BOTTOM w0.121: R213.1 35.43,28.92 35.31,29.05 34.54,29.05 34.42,29.18 R214.1 33.94,30 30.26,30 30.1,29.84 v1(30.1,29.53)
RXDV: length 2.9
  TOP w0.121: 21.46,35.05 22.1,35.05 22.67,34.48 22.67,34.1 23.13,33.64 U15.26
RXER/PHYAD0: length 7.6
  TOP w0.121: R137.2 v1(30.1,33.34) 30.1,33.02 29.97,32.89 29.47,32.89 29.21,32.64 U15.13
  BOTTOM w0.121: R126.2 33.21,33.34 32.73,33.81 31.4,33.81 R137.2 v1(30.1,33.34)
RXN: length 20.3
  TOP w0.095: U15.30 22.99,31.63 22.85,31.5 22.29,31.5 v1(22.23,31.43) 21.89,31.1 21.61,31.1 21.08,31.62 21.08,33.16 20.18,34.06 19.19,34.06 18.52,33.39 18.52,32.74 17.78,32 16.52,32 16,32.53 16,33.97 16.13,34.1 17.02,34.1 17.14,33.97 P10.2
  BOTTOM w0.095: 21.46,31.43 v1(22.23,31.43)
  BOTTOM w0.121: P10.2 C127.1
RXP: length 17.8
  TOP w0.095: P10.1 15.49,34.29 15.72,34.06 15.72,32.41 16.41,31.72 17.9,31.72 18.8,32.62 18.8,33.27 19.3,33.78 20.07,33.78 20.8,33.05 20.8,31.51 21.49,30.82 21.89,30.82 v1(22.23,30.48) 22.48,30.73 22.48,31.06 22.63,31.22 22.89,31.22 22.97,31.13 U15.31
  BOTTOM w0.095: 21.46,30.48 v1(22.23,30.48)
  BOTTOM w0.121: P10.1 C126.1
SD_CD: length 8.4
  BOTTOM w0.121: R197.1 70.36,46.86 70.48,46.74 70.48,45.97 70.61,45.85 71.12,45.85 71.12,45.09 72.15,44.05 72.15,41.93 71.61,41.38 P4.10
SPI1_CS0: length 28.3
  TOP w0.121: v1(47.13,28.69) U5.C12
  LYR4 w0.133: v1(47.13,28.69) 46.1,27.66 46.1,26.67 45.72,26.29 45.72,23.75 46.1,23.37 46.1,21.97 48.64,19.43 48.64,10.54 50.29,8.89 50.29,7.87 52.7,5.46 P9.28
SPI1_D0: length 31.4
  TOP w0.121: v1(47.13,27.89) U5.B13
  LYR4 w0.133: 55.24,1.91 53.72,3.43 53.72,4.95 50.67,8 50.67,15.49 48.9,17.27 48.9,19.56 46.35,22.1 46.35,22.86 47.5,24 47.5,26.42 47.24,26.67 46.85,26.67 46.72,26.8 46.72,27.48 v1(47.13,27.89)
SPI1_D1: length 29.5
  TOP w0.121: v1(47.13,29.49) U5.D12
  LYR4 w0.121: 47.53,28.35 47.53,29.09 v1(47.13,29.49)
  LYR4 w0.133: 47.53,28.35 48.13,27.75 48.13,21.08 49.4,19.81 49.4,17.53 51.44,15.49 51.44,8.64 52.32,7.75 53.21,7.75 55.24,5.71 55.24,4.45
SPI1_SCLK: length 32.4
  TOP w0.121: v1(47.13,27.09) U5.A13
  LYR4 w0.133: P9.31 56.52,3.17 54.86,3.17 54.23,3.81 54.23,6.22 52.96,7.49 52.07,7.49 51.05,8.51 51.05,15.49 49.15,17.4 49.15,19.68 47.12,21.72 47.12,22.1 47.75,22.73 47.75,26.8 47.46,27.09 v1(47.13,27.09)
SYS_5V: length 134.2
  TOP w0.203: 21.59,16.13 21.81,15.91 U2.8 ; 21.59,16.13 21.77,16.31 U2.7 ; 21.59,16.13 v1(21.46,16.13)
  TOP w0.381: v1(12.64,45.34) 12.64,46.61 FB4.2
  TOP w0.508: C133.1 70.47,14.63 75.27,14.63 v1(75.57,14.93)
  LYR3 w0.508: v1(75.57,14.93) 74.8,14.16 74.8,12.57 67.94,5.71 27.3,5.71
  LYR3 w0.762: P9.8 27.3,5.71 23.11,9.91 19.68,9.91 v1(18.8,10.79)
  LYR4 w0.381: v1(12.64,45.34) 11.43,44.13 11.43,41.4 14.99,37.85 17.91,37.85 20.32,35.43 20.32,22.86 19.05,21.59 19.05,19.56 20.32,18.29 20.32,16.13
  LYR4 w0.762: v1(21.46,16.13) 20.32,16.13 20.32,14.73 18.8,13.21 v1(18.8,11.56) v1(18.8,10.79)
  BOTTOM w0.381: v1(12.64,45.34) 13.14,45.85 18.41,45.85 ; 18.03,10.79 18.03,11.3 18.29,11.56 v1(18.8,11.56) v1(18.8,10.79) ; 18.03,10.79 18.03,10.16 R3.2 18.8,10.16 v1(18.8,10.79) ; 18.03,10.79 v1(18.8,10.79) ; U9.3 v1(75.57,14.93) 75.56,14.92 75.56,14.61 75.89,14.28 U9.2
  BOTTOM w0.762: P9.7 P9.8
SYS_RESETN: length 80
  TOP w0.121: U5.A10 49.13,27.16 48.76,26.79 48.76,26.03 46.86,24.13 v1(46.86,22.61) ; R27.1 R23.2 10.16,41.47 v1(10.29,41.59) ; U15.19 v1(26.79,35.81)
  LYR3 w0.133: v1(46.86,22.61) 45.59,21.34 35.69,21.34 35.31,21.72 34.16,21.72 33.66,21.21 v1(33.02,21.21) ; v1(22.23,35.81) 21.08,36.96 14.61,36.96 11.81,39.75 11.07,39.75 10.69,40.13 10.69,41.19 v1(10.29,41.59)
  LYR4 w0.133: P9.10 29.08,5.21 29.08,11.94 29.36,12.22 30,12.22 31.11,13.34 31.11,17.14 32.51,18.54 32.51,20.7 v1(33.02,21.21) 31.62,22.61 31.62,25.65 29.34,27.94 28.96,27.94 27.94,28.96 27.94,34.66 v1(26.79,35.81) 26.28,35.31 22.73,35.31 v1(22.23,35.81)
SYS_VOLT: length 56.6
  TOP w0.203: v1(29.46,17.27) 29.34,17.27 29.17,17.11 U2.32 ; v1(21.46,18.67) 21.82,18.31 U2.2 ; U2.21 26.4,12.77 26.67,12.5 v1(26.67,12.45) 26.8,12.58 U2.22 ; U2.39 v1(26.8,20.32) ; U2.42 25.6,20.3 v1(25.62,20.32)
  TOP w0.381: v1(16.76,10.16) 16.76,9.6 U8.8 17.5,9.55 18.03,9.02 v1(18.03,6.99) v1(18.8,6.99)
  LYR3 w0.635: v1(25.62,20.32) 25.62,18.8 ; v1(26.8,20.32) 26.8,18.8 26.8,18.8
  LYR3 w0.762: v1(18.03,6.99) v1(18.8,6.99) 21.87,6.99 v1(22.86,5.97) ; v1(29.46,17.27) 29.46,17.91 28.57,18.8 21.59,18.8 v1(21.46,18.67)
  LYR4 w0.762: v1(22.86,5.97) 22.86,7.75 26.67,11.56 v1(26.67,12.45) 28.45,14.22 28.45,16.26 v1(29.46,17.27)
  BOTTOM w0.381: v1(21.46,18.67) 21.46,18.03 21.59,17.91 22.1,17.91 C19.2 ; v1(29.46,17.27) 28.51,17.27 C10.2 ; C6.1 17.02,9.91 v1(16.76,10.16) ; R2.2 v1(22.86,5.97) ; v1(26.67,12.45) 26.35,12.76 C8.2 C9.2 ; C18.2 26.8,19.75 v1(26.8,20.32) ; C17.2 24.45,20 24.77,20.32 v1(25.62,20.32) ; 18.03,7.62 v1(18.03,6.99) v1(18.8,6.99) 18.8,7.62 18.41,8 18.03,7.62
SYS_WARMRESETN: length 33
  TOP w0.121: S1.2 5.51,40.67 5.73,40.45 C101.1 R27.2 8.26,39.91 8.48,39.69 10.48,39.69 v1(11.11,40.32)
  LYR3 w0.133: v1(11.11,40.32) 11.75,40.32 14.73,37.34 21.08,37.34 23.11,39.37 28.07,39.37 29.72,41.02 29.72,41.27 v1(29.08,41.91)
  BOTTOM w0.121: v1(29.08,41.91) 29.21,42.04 29.84,42.04 30.23,42.42 R163.2
TCK: length 2.8
  BOTTOM w0.121: R180.2 64.29,13.34
TCT_RCT: length 6.4
  BOTTOM w0.121: P10.4 15.88,29.21 P10.5 R142.1 C130.1
TDIS: length 8.8
  BOTTOM w0.121: 69.7,8.26 67.18,8.26 66.55,8.89 62.74,8.89 62.1,8.26 R177.1
TESTOUT: length 2.6
  TOP w0.121: TP6.1 54.58,25.43 54.58,27.34 U5.A3
TIMER4: length 30.2
  TOP w0.121: v1(51.93,39.09) U5.R7
  LYR3 w0.121: v1(51.93,39.09) 51.53,39.49 51.53,40.29
  LYR3 w0.133: 51.53,40.29 44.45,47.37 41.02,47.37 40.13,48.26 31.24,48.26 30.73,48.77 28.7,48.77 P8.7
TIMER5: length 27.7
  TOP w0.121: v1(52.73,39.89) U5.T6
  LYR3 w0.133: v1(52.73,39.89) 43.85,48.77 31.75,48.77 31.24,49.28 30.73,49.28 P8.9
TIMER6: length 30.2
  TOP w0.121: U5.U6 52.73,40.69 52.73,41.5 51.69,42.55 51.69,43.31 51.41,43.59 51.28,43.59 50.86,44.01 v1(50.49,44.01)
  LYR3 w0.133: P8.10 31.11,51.44 31.11,49.91 32,49.02 43.92,49.02 43.94,49 43.95,49 48.95,44.01 v1(50.49,44.01)
TIMER7: length 31.7
  TOP w0.121: v1(51.93,39.89) U5.T7
  LYR3 w0.133: v1(51.93,39.89) 51.93,40.27 44.58,47.62 41.15,47.62 40.26,48.51 31.5,48.51 30.99,49.02 29.34,49.02 28.57,49.78 28.57,51.44 P8.8
TXCLK: length 5.8
  TOP w0.121: U15.20 26.29,35.48 26.37,35.56 26.37,35.99 26.64,36.26 30.86,36.26 R206.2
TXN: length 22.8
  TOP w0.095: U15.28 22.55,32.64 22.23,32.96 v1(22.23,33.34)
  LYR3 w0.102: P10.6 17.14,28.96 16.38,29.72 16.03,29.72 15.9,29.59 15.9,27.41 16.46,26.85 18.21,26.85 21.08,29.72 21.08,32.51 21.51,32.94 21.83,32.94 v1(22.23,33.34)
  BOTTOM w0.095: 21.46,33.34 v1(22.23,33.34)
  BOTTOM w0.121: P10.6 C129.1
TXP: length 20.3
  TOP w0.095: U15.29 22.99,32.13 22.77,32.36 22.24,32.36 22.22,32.37 v1(22.22,32.38)
  LYR3 w0.102: v1(22.23,32.38) 21.97,32.64 21.64,32.64 21.39,32.39 21.39,29.59 18.34,26.54 16.33,26.54 15.6,27.28 15.6,30.76 P10.3
  BOTTOM w0.095: 21.46,32.38 v1(22.23,32.38)
  BOTTOM w0.121: C128.1 P10.3
U5_H18: length 5
  TOP w0.121: U5.H18 41.98,33.09 41.02,32.13 40.01,32.13 39.37,31.5 R201.1
UART0_CTS: length 19.4
  TOP w0.121: U5.E17 43.13,30.29 42.1,30.29 40.91,29.1 39.89,29.1 39.24,28.45 38.86,28.45 38.48,28.07 38.48,24.64 41.91,21.21 44.07,21.21 45.33,19.94 U12.40
UART0_RTS: length 18.8
  TOP w0.121: U12.41 44.84,20.06 43.94,20.95 41.78,20.95 38.23,24.51 38.23,28.19 38.73,28.7 39.08,28.7 40.36,29.97 41.15,29.97 41.87,30.69 U5.E18
UART0_RX: length 15.8
  TOP w0.121: v1(45.34,17.65) 45.59,17.65 45.84,17.9 U12.39 ; v1(43.93,30.29) U5.E16
  LYR4 w0.133: v1(45.34,17.65) 45.34,18.67 44.45,19.56 44.45,20.57 43.69,21.34 43.69,26.54 43.43,26.8 43.43,29.79 v1(43.93,30.29)
UART0_TX: length 19.2
  TOP w0.121: v1(45.34,16.89) 45.34,16.91 46.33,17.9 U12.38 ; v1(44.73,30.29) U5.E15
  LYR4 w0.121: v1(44.73,30.29) 44.33,30.69 43.64,30.69 43.56,30.61
  LYR4 w0.133: 43.56,30.61 43.18,30.23 43.18,26.67 43.43,26.42 43.43,21.24 44.2,20.48 44.2,19.3 44.83,18.67 44.83,17.4 v1(45.34,16.89)
UART1_RXD: length 31.9
  TOP w0.121: v1(43.93,29.49) U5.D16
  LYR4 w0.121: 44.33,26.8 44.33,29.09 v1(43.93,29.49)
  LYR4 w0.133: P9.26 49.02,3.3 47.12,3.3 46.61,3.81 46.61,5.21 45.85,5.97 45.85,18.67 44.7,19.81 44.7,20.7 43.94,21.46 43.94,23.37 44.32,23.75 44.32,26.8 44.33,26.8
UART1_TXD: length 27.7
  TOP w0.121: v1(44.73,29.49) U5.D15
  LYR4 w0.121: 45.13,28.45 45.13,29.09 v1(44.73,29.49)
  LYR4 w0.133: 45.13,28.45 45.21,28.37 45.21,26.92 44.83,26.54 44.83,23.5 44.2,22.86 44.2,21.59 44.96,20.83 44.96,20.07 46.1,18.92 46.1,8.26 47.62,6.73 P9.24
UART2_RXD: length 24.4
  TOP w0.121: U5.A17 43.43,27.39 43.43,22.99 v1(42.67,22.23)
  LYR4 w0.133: P9.22 45.09,7.37 43.69,8.76 43.69,20.2 43.16,20.73 43.15,20.73 42.67,21.21 v1(42.67,22.23)
UART2_TXD: length 29.7
  TOP w0.121: v1(41.91,22.23) 42.42,22.73 42.83,22.73 43.18,23.09 43.18,27.06 43.13,27.11 43.13,27.89 U5.B17
  LYR4 w0.133: v1(41.91,22.23) 41.91,21.59 42.55,20.95 42.55,18.66 43.43,17.78 43.43,14.99 42.77,14.33 42.77,9.04 44.7,7.11 44.7,5.71 44.07,5.08 44.07,2.92 P9.21
UART3_CTSN: length 28.9
  TOP w0.121: 53.34,45.85 v1(53.34,45.09) 55.13,43.3 55.13,40.69 U5.U3
  LYR3 w0.133: P8.36 61.85,51.69 61.85,49.66 62.48,49.02 64.26,49.02 65.4,47.88 65.41,47.88 65.66,47.63 65.66,47.24 65.41,46.99 55.24,46.99 v1(53.34,45.09)
  BOTTOM w0.121: 53.34,45.85 v1(53.34,45.09)
UART3_RTSN: length 29.8
  TOP w0.121: U5.U4 54.33,40.69 54.33,41.94 53.59,42.67 53.59,43.81 52.74,44.67 51.85,44.67 v1(51.44,45.09) 51.44,45.85
  LYR3 w0.133: P8.34 59.31,51.69 59.31,49.15 59.44,49.02 60.45,49.02 60.58,48.9 60.58,48.64 60.45,48.51 49.15,48.51 49.02,48.39 49.02,47.5 v1(51.44,45.09)
  BOTTOM w0.121: 51.44,45.85 v1(51.44,45.09)
UART4_CTSN: length 29.8
  TOP w0.121: U5.V2 55.53,43.85 v1(54.29,45.09) 54.29,45.85
  LYR3 w0.133: v1(54.29,45.09) 54.29,45.15 55.88,46.74 67.44,46.74 67.69,46.99 67.69,47.95 67.44,48.2 65.47,48.2 64.14,49.53 64.14,51.31 63.88,51.56 63.12,51.56 62.87,51.31 P8.35
  BOTTOM w0.121: 54.29,45.85 v1(54.29,45.09)
UART4_RTSN: length 29.5
  TOP w0.121: U5.V3 54.73,41.95 53.85,42.83 53.85,43.94 52.7,45.09 v1(52.39,45.09) 52.39,45.85
  LYR3 w0.133: P8.33 61.85,48.64 64.01,48.64 64.14,48.51 64.14,48.26 64.01,48.13 50.16,48.13 50.04,48.01 50.04,47.43 v1(52.39,45.09)
  BOTTOM w0.121: 52.39,45.85 v1(52.39,45.09)
UART4_RXD: length 54.5
  TOP w0.121: v1(31.75,40.01) 32.26,40.51 35.18,40.51 36.03,39.66 40.13,39.66 40.36,39.89 43.13,39.89 U5.T17
  LYR4 w0.133: P9.11 33.66,3.17 33.66,4.83 35.31,6.48 35.31,7.87 34.54,8.64 34.54,13.34 35.05,13.84 35.05,20.7 35.43,21.08 35.43,25.15 32,28.57 32,36.32 32.51,36.83 32.51,38.35 31.75,39.12 v1(31.75,40.01)
UART4_TXD: length 47.6
  TOP w0.121: U5.U17 43.13,40.69 42.37,40.69 42.19,40.51 40.26,40.51 39.9,40.15 38.59,40.15 v1(38.1,40.64)
  LYR4 w0.133: P9.13 36.07,3.05 36.07,11.18 36.7,11.81 36.7,13.59 35.56,14.73 35.56,20.45 35.94,20.83 35.94,32.38 38.86,35.31 38.86,38.1 38.1,38.86 v1(38.1,40.64)
UART5_CTSN: length 29.2
  TOP w0.121: 50.48,45.85 v1(50.48,45.09) 50.99,44.58 51.56,44.58 51.71,44.42 52.61,44.42 53.34,43.69 53.34,42.55 53.93,41.95 U5.V4
  LYR3 w0.133: v1(50.48,45.09) 47.24,48.32 47.24,48.77 47.5,49.02 58.67,49.02 58.93,49.28 58.93,51.31 58.67,51.56 58.04,51.56 57.78,51.31 P8.31
  BOTTOM w0.121: 50.48,45.85 v1(50.48,45.09)
UART5_RTSN: length 29.6
  TOP w0.121: v1(53.53,39.89) U5.T5 ; 49.53,45.85 v1(49.53,45.09)
  LYR3 w0.133: P8.32 56.77,51.69 47.37,51.69 46.48,50.8 46.48,48.13 v1(49.53,45.09)
  BOTTOM w0.121: 49.53,45.85 v1(49.53,45.09) 50.04,44.58 52.83,44.58 53.53,43.88 v1(53.53,39.89)
UART5_RXD: length 29.3
  TOP w0.121: 55.24,45.85 v1(55.24,45.09) 55.88,44.45 55.88,41.45 55.93,41.4 55.93,40.69 U5.U2
  LYR3 w0.133: P8.38 64.39,51.69 64.39,49.66 65.53,48.51 67.69,48.51 67.94,48.26 67.94,46.74 67.69,46.48 56.64,46.48 v1(55.24,45.09)
  BOTTOM w0.121: 55.24,45.85 v1(55.24,45.09)
UART5_TXD: length 29.3
  TOP w0.121: 56.2,45.85 v1(56.2,45.09) 56.83,44.45 56.83,40.79 U5.U1
  LYR3 w0.133: P8.37 65.41,51.31 65.66,51.56 66.29,51.56 66.55,51.31 66.55,49.02 66.8,48.77 67.94,48.77 68.2,48.51 68.2,45.57 67.94,45.32 65.93,45.32 65.02,46.23 57.34,46.23 v1(56.2,45.09)
  BOTTOM w0.121: 56.2,45.85 v1(56.2,45.09)
USB0_DM: length 25.6
  TOP w0.114: U5.N18 42.61,37.21 41.43,37.21 40.54,38.1 36.05,38.1 35.7,38.46 23.61,38.46 22.21,37.06 20.59,37.06 20.18,37.48 20.18,37.9 20.1,37.97 19.89,37.97 19.81,38.05 19.81,38.16 19.96,38.3 U11.2
USB0_DP: length 25.7
  TOP w0.114: U11.3 20.45,37.59 20.71,37.34 22.1,37.34 23.5,38.73 35.81,38.73 36.17,38.38 40.66,38.38 41.55,37.49 43.13,37.49 U5.N17
USB0_ID: length 12
  TOP w0.121: TP4.1 35.56,39.62 36.45,38.73 37.72,38.73 38.23,39.24 v1(39.75,39.24) ; U5.P16 v1(43.93,38.29)
  BOTTOM w0.121: v1(39.75,39.24) 40.26,39.75 42.79,39.75 43.43,39.11 43.43,38.79 v1(43.93,38.29)
USB0_VBUS: length 37.8
  TOP w0.121: U16.4 35.42,41.26 v1(36.07,41.91) ; v1(44.73,38.29) U5.P15
  LYR3 w0.133: v1(36.07,41.91) 34.16,43.81 25.91,43.81 22.86,46.86 v1(17.53,46.86)
  BOTTOM w0.121: v1(36.07,41.91) 36.07,42.67 36.7,43.31 42.8,43.31 43.94,42.16 43.94,40.64 44.33,40.25 44.33,38.69 v1(44.73,38.29) ; R152.2 v1(17.53,46.86)
USB0_VBUS_PWR: length 9.2
  TOP w0.121: U11.11 24.51,41.27 25.15,40.64 27.81,40.64 28.57,41.4 31.1,41.4 31.24,41.26 U16.3
USB1_DM: length 65.2
  TOP w0.114: U5.R18 42.61,38.81 42.12,38.81 41.91,38.59 v1(41.91,38.35)
  LYR3 w0.127: v1(42.93,16.89) 42.52,16.49 42.52,15.9 42.85,15.57 61.04,15.57 62.15,16.68 72.52,16.68 P2.2 76.59,15.83 77.9,17.14 v1(78.11,17.14)
  LYR4 w0.127: v1(42.93,16.89) 42.04,16.89 41.4,17.53 41.4,20.75 40.77,21.39 40.77,25.1 41.27,25.6 41.27,37.47 41.91,38.1 v1(41.91,38.35)
  BOTTOM w0.114: U10.2 78.58,18.41 78.36,18.19 77.96,18.19 77.71,17.94 77.71,17.54 v1(78.11,17.14)
USB1_DP: length 65.2
  TOP w0.114: v1(41.27,38.35) 42.01,39.09 43.13,39.09 U5.R17
  LYR3 w0.127: v1(42.93,16.13) 43.18,15.88 60.91,15.88 62.02,16.99 72.52,16.99 P2.3 74.17,17.04 74.17,16.64 74.67,16.14 76.46,16.14 v1(78.11,17.78)
  LYR4 w0.127: v1(41.27,38.35) 41.27,37.9 40.97,37.59 40.97,25.73 40.46,25.22 40.46,21.26 41.1,20.62 41.1,17.4 41.99,16.51 42.55,16.51 v1(42.93,16.13)
  BOTTOM w0.114: U10.1 78.24,17.92 v1(78.11,17.78)
USB1_DRVVBUS: length 45.7
  TOP w0.121: U5.F15 v1(44.73,31.09)
  LYR4 w0.121: v1(44.73,31.09) 45.13,30.69 45.13,30.12 45.36,29.89 45.93,29.89 v1(46.33,29.49)
  BOTTOM w0.121: v1(46.33,29.49) 46.73,29.09 46.73,28.31 45.72,27.3 45.72,24.38 46.48,23.62 51.69,23.62 53.98,21.34 58.42,21.34 59.18,22.1 69.47,22.1 72.52,19.05 75.06,19.05 76.2,17.91 R147.1 76.83,17.14 77.06,16.92 U9.4
USB1_ID: length 1.9
  TOP w0.121: v1(43.13,38.29) 43.18,38.24 U5.P17
  BOTTOM w0.121: v1(43.13,38.29) 43.13,38.89 42.93,39.09 R146.1
USB1_OC: length 71.5
  TOP w0.121: v1(43.93,39.89) U5.T16
  LYR3 w0.133: v1(42.93,17.65) 43.43,18.16 48.39,18.16 49.53,17.02 60.07,17.02 62.1,19.05 78.74,19.05 79.76,18.03 82.3,18.03 v1(83.19,17.14)
  LYR4 w0.133: v1(43.93,39.89) 43.32,39.89 42.32,38.89 42.32,38 41.66,37.34 41.66,27.94 41.55,27.83 41.55,26.27 41.78,26.04 41.78,24.51 41.15,23.88 41.15,21.72 42.32,20.55 42.32,18.26 v1(42.93,17.65)
  BOTTOM w0.121: U9.5 82.89,15.58 83.19,15.88 v1(83.19,17.14) R148.2
USB1_VBUS: length 83.5
  TOP w0.381: U5.T18 40.76,39.49 v1(40.52,39.25)
  TOP w0.635: v1(81.92,17.14) 83.18,15.88 v1(83.18,14.93)
  LYR3 w0.381: v1(42.16,13.84) 43.31,12.7 55.12,12.7 55.75,13.34 P2.1
  LYR4 w0.381: v1(42.16,13.84) 40.13,15.88 40.13,19.43 39.62,19.94 39.62,28.07 39.94,28.38 39.94,38.67 v1(40.52,39.25)
  BOTTOM w0.305: C134.1 81.91,17.92 U10.6
  BOTTOM w0.381: C134.1 v1(81.92,17.14) ; U9.6 v1(83.18,14.93) ; 83.18,13.63 U9.8 ; 83.18,14.28 U9.7
  BOTTOM w0.635: P2.1 74.26,12.45 82.68,12.45 83.18,12.95 v1(83.18,14.93)
USB_DC: length 54.2
  TOP w0.121: U2.12 22.33,13.72 21.82,13.21 v1(21.46,13.21)
  LYR4 w0.133: v1(12.06,43.18) 12.06,41.4 15.11,38.35 18.16,38.35 20.7,35.81 20.7,21.27 21.02,20.95 21.02,17.84 22.23,16.64 22.23,13.97 v1(21.46,13.21)
  BOTTOM w0.121: v1(21.46,13.21) 21.72,13.46 C2.1 ; R149.1 19.3,46.86 19.05,46.61 19.05,45.21 18.67,44.83 12.83,44.83 12.06,44.07 v1(12.06,43.18) 11.73,42.85 P3.1
USBDM_DN: length 12.3
  TOP w0.114: U11.21 18.81,43.68 18.26,44.22 10.48,44.22 v1(9.91,43.65)
  BOTTOM w0.114: P3.2 v1(9.91,43.65)
USBDP_UP: length 12.3
  TOP w0.114: v1(10.67,43.65) 10.96,43.94 18.15,43.94 18.55,43.53 U11.22
  BOTTOM w0.114: P3.3 8.89,44.45 9.27,44.07 10.25,44.07 v1(10.67,43.65)
USR0: length 21.1
  TOP w0.121: U5.V15 45.13,41.36 44.45,42.04 41.53,42.04 40.77,42.8 40.51,42.8 39.62,43.69 36.64,43.69 35.18,45.15 35.18,46.74 33.66,48.26 33.27,48.26 33.02,48.01 33.02,46.48 32.89,46.35 Q1.2 31.62,46.35 31.37,46.1 v1(31.37,45.72)
  BOTTOM w0.121: v1(31.37,45.72) R116.1
USR1: length 17
  TOP w0.121: Q1.5 34.42,46.35 34.67,46.1 v1(34.67,45.72) 34.67,45.02 36.26,43.43 39.5,43.43 40.39,42.55 40.64,42.55 41.4,41.78 44.2,41.78 44.49,41.49 44.5,41.49 44.73,41.26 44.73,40.69 U5.U15
  BOTTOM w0.121: v1(34.67,45.72) 34.67,46.61 34.29,46.99 R117.1
USR2: length 23.2
  TOP w0.121: v1(44.73,39.89) U5.T15 ; Q2.2 27.81,46.35 27.56,46.1 v1(27.56,45.72)
  LYR3 w0.133: v1(27.56,45.72) 30.23,45.72 31.75,44.2 34.54,44.2 37.08,41.66 39.37,41.66 40.01,41.02 41.15,41.02 41.78,41.66 42.96,41.66 v1(44.73,39.89)
  BOTTOM w0.121: v1(27.56,45.72) R118.1
USR3: length 22.4
  TOP w0.121: U5.V16 43.89,41.53 41.66,41.53 41.27,41.15 40.26,41.15 40.01,41.4 40.01,42.55 39.37,43.18 35.88,43.18 34.61,44.45 29.59,44.45 29.21,44.83 29.21,46.23 29.34,46.35 Q2.5 30.61,46.35 30.86,46.61 v1(30.86,46.99)
  BOTTOM w0.121: v1(30.86,46.99) R119.1
VDCDC1: length 1.1
  TOP w0.203: U2.19 25.6,12.65 v1(25.4,12.45)
VDCDC3: length 8
  TOP w0.203: v1(29.46,15.75) 29.3,15.91 U2.29
  BOTTOM w0.508: v1(29.46,15.75) 29.97,16.26 v1(36.2,16.26)
VREFP_ADC: length 7.1
  TOP w0.121: 49.4,26.92 49.53,27.05 49.53,27.89
  TOP w0.305: 49.4,26.92 49.1,26.62 49.1,25.7 48.55,25.15 R78.2 48.58,24.73 ; 49.53,27.89 U5.B9
  TOP w0.381: C29.1 C28.1 ; C29.1 C30.1 ; C29.1 48.58,24.73
VRTC: length 51.4
  TOP w0.203: U2.3 21.21,17.91
  TOP w0.254: U17.2 32.32,22.79 32.51,22.99 32.51,23.29 ; v1(34.92,23.81) 34.67,23.81 34.49,23.63 U17.8 33.52,23.29 v1(33.02,23.79) 32.52,23.29 32.51,23.29 ; U17.1 32.51,23.29
  TOP w0.305: v1(51.93,29.49) U5.D7
  TOP w0.381: v1(19.68,17.78) 19.82,17.91 21.21,17.91
  LYR3 w0.381: v1(19.68,17.78) 19.05,18.41 19.05,20.83 20.83,22.61 31.83,22.61 v1(33.02,23.79) ; v1(34.92,23.81) 35.62,23.81 36.58,24.77 38.73,24.77 39.24,25.27 50.23,25.27 v1(51.12,26.16) v1(53.09,26.16)
  BOTTOM w0.152: R77.1 53.61,24.26 53.48,24.38 53.48,25.77 v1(53.09,26.16)
  BOTTOM w0.381: v1(51.12,26.16) C98.1 ; C20.1 v1(19.68,17.78) ; C21.1 v1(34.92,23.81)
VRTC_DET: length 2.5
  TOP w0.121: U17.7 33.03,22.79 v1(33.02,22.8)
  BOTTOM w0.121: v1(33.02,22.8) 32.77,23.05 R17.1
VRTC_DET_OUT: length 3.2
  TOP w0.121: v1(31.11,21.21) 30.73,21.21 30.61,21.34 30.61,22.17 30.73,22.29 U17.3
  BOTTOM w0.121: R143.1 v1(31.11,21.21)
VRTC_DETB: length 5.1
  TOP w0.121: U17.5 33.26,21.79 v1(33.02,22.03) 33.28,22.29 U17.6
  BOTTOM w0.121: C22.1 v1(33.02,22.03) R17.2
WAKEUP: length 51.3
  TOP w0.121: U5.C5 v1(53.53,28.69)
  LYR3 w0.133: v1(28.07,12.45) 28.83,13.21 28.83,15.75 29.34,16.26 31.11,16.26 35.66,20.8 54.78,20.8 v1(55.88,21.91)
  LYR4 w0.133: v1(55.88,21.91) 55.88,26.34 v1(53.53,28.69)
  BOTTOM w0.121: R77.2 53.98,25.91 53.13,26.75 53.13,28.05 53.36,28.29 53.37,28.29 53.53,28.45 v1(53.53,28.69) ; R11.2 24.38,14.48 24.77,14.1 24.77,13.65 26.47,11.94 27.56,11.94 v1(28.07,12.45)
XDMA_EVENT_INTR0: length 26.1
  TOP w0.121: v1(44.73,27.09) U5.A15
  BOTTOM w0.121: R183.1 59.82,17.14 58.67,16 53.09,16 51.94,17.14 51.94,21.72 51.31,22.35 47.37,22.35 47.12,22.1 46.48,22.1 44.73,23.85 v1(44.73,27.09)
XTALIN: length 7.4
  TOP w0.121: 15.37,41.75 C137.2 v1(13.34,41.27) ; 15.37,41.75 18.55,41.75 U11.24 ; 15.37,41.75 R160.1
  BOTTOM w0.121: Y5.3 14.29,41.27 v1(13.34,41.27)
XTALOUT: length 5.1
  TOP w0.121: v1(17.14,43.18) C144.2 R160.2 16.43,42.27 U11.23
  BOTTOM w0.121: v1(17.14,43.18) 16.19,43.18 Y5.1
XTIN: length 10.7
  TOP w0.121: v1(42.23,9.53) 41.84,9.13 U12.2
  BOTTOM w0.121: C153.2 37.47,12.57 37.72,12.83 40.89,12.83 41.11,12.61 Y6.3 41.83,11.38 42.04,11.18 42.04,9.72 v1(42.23,9.53)
XTOUT: length 8.9
  TOP w0.121: v1(42.23,6.35) 42.33,6.46 U12.3
  BOTTOM w0.121: v1(42.23,6.35) 41.97,6.1 37.85,6.1 37.47,6.48 C155.2 38.66,7.43 Y6.1
N21069846: length 9
  TOP w0.121: v1(29.21,28.57) 27.39,28.57 27.35,28.54 26.71,28.54 v1(26.29,28.96) 26.29,29.21 26.29,29.21 U15.5
  BOTTOM w0.121: v1(29.21,28.57) 29.69,29.05 30.45,29.05 R200.2 ; v1(26.29,28.96) 27.3,27.94 R199.2
N21185557: length 2.4
  BOTTOM w0.121: R16.2 4.57,27.28 P10.11
N21240440: length 2.9
  BOTTOM w0.121: U7.7 29.78,8.45 29.97,8.64 31.24,8.64 31.5,8.89 R210.2
N21242283: length 2
  BOTTOM w0.121: P10.10 4.57,33.32 R128.2

## Copper pours and planes (outline as drawn)
DGND on TOP (solid shape): 16,6.92 14.48,6.92 14.48,10.22 16,10.22
DGND on TOP (solid shape): 81.28,12.7 77.47,12.7 77.47,16.51 81.28,16.51
DGND on BOTTOM (solid shape): 16.51,9.65 16.51,7.37 16,6.86 14.48,6.86 13.97,7.37 13.97,9.65 14.48,10.16 16,10.16
DGND on TOP: 21.21,24.64 21.21,28.07 21.46,28.32 28.07,28.32 28.32,28.07 28.32,24.64 28.07,24.38 21.46,24.38
DGND on BOTTOM: 45.09,35.56 45.21,35.69 45.21,36.07 45.72,36.07 45.72,35.69 45.97,35.43 45.97,34.8 45.72,34.54 45.72,34.16 45.09,34.16
DGND on BOTTOM: 12.83,40.39 12.83,44.07 13.08,44.32 17.4,44.32 17.65,44.07 17.65,40.39 17.4,40.13 13.08,40.13
DGND on BOTTOM: 37.08,6.35 36.83,6.6 36.83,6.8 36.88,6.99 36.83,7.17 36.83,12.32 37.08,12.57 41.66,12.57 41.91,12.32 41.91,6.6 41.66,6.35
DGND on LYR2_GND: 10.16,3.49 12.7,6.03 16.51,6.03 18.1,4.45 18.1,1.91 18.73,1.27 73.98,1.27 75.27,1.51 76.52,1.91 77.15,2.54 77.15,8.26 76.52,8.89 74.61,8.89 73.98,9.53 73.98,11.11 74.61,11.75 83.19,11.75 83.82,12.38 83.82,21.27 83.19,21.91 74.61,21.91 73.98,22.54 73.98,24.13 74.61,24.77 83.19,24.77 83.82,25.4 83.82,44.13 83.19,44.77 77.47,44.77 77.15,45.09 77.15,52.07 76.52,52.7 75.13,53.22 73.66,53.34 18.73,53.34 18.1,52.7 18.1,50.16 16.51,48.58 12.7,48.58 12.06,49.21 2.22,49.21 1.59,48.58 1.59,40.32 2.22,39.69 11.75,39.69 12.7,38.73 12.7,36.83 12.06,36.2 10.48,36.2 9.21,37.47 2.54,37.47 1.91,36.83 1.91,31.43 2.54,30.8 2.54,28.89 1.91,28.26 1.91,22.86 2.54,22.23 9.21,22.23 10.48,23.5 12.06,23.5 12.7,22.86 12.7,20.95 11.75,20 2.54,20 1.91,19.37 1.91,5.4 3.81,3.49
GND_EARTH on TOP: 6.35,0.64 2.31,2.31 0.64,6.35 0.64,48.26 2.31,52.3 6.35,53.98 73.66,53.98 82.19,50.44 85.72,41.91 85.72,40.01 85.09,39.37 85.09,28.26 85.72,27.62 85.72,12.7 82.19,4.17 73.66,0.64 ; 1 cut-out
GND_EARTH on BOTTOM: 6.35,0.64 2.31,2.31 0.64,6.35 0.64,48.26 2.31,52.3 6.35,53.98 73.66,53.98 82.19,50.44 85.72,41.91 85.72,40.01 85.09,39.37 85.09,28.26 85.72,27.62 85.72,12.7 82.19,4.17 73.66,0.64 ; 1 cut-out
GND_EARTH on LYR2_GND: 6.35,0.64 2.31,2.31 0.64,6.35 0.64,48.26 2.31,52.3 6.35,53.98 73.66,53.98 82.19,50.44 85.72,41.91 85.72,40.01 85.09,39.37 85.09,28.26 85.72,27.62 85.72,12.7 82.19,4.17 73.66,0.64 ; 1 cut-out
GND_EARTH on LYR5_PWR: 6.35,0.64 2.31,2.31 0.64,6.35 0.64,48.26 2.31,52.3 6.35,53.98 73.66,53.98 82.19,50.44 85.72,41.91 85.72,40.01 85.09,39.37 85.09,28.26 85.72,27.62 85.72,12.7 82.19,4.17 73.66,0.64 ; 1 cut-out
GND_OSC0 on BOTTOM: 37.97,43.81 47.12,43.81 47.37,44.07 47.37,48.64 47.12,48.9 37.97,48.9 37.72,48.64 37.72,44.07
GND_OSC1 on TOP: 53.66,20.19 53.66,12.45 59.37,12.45 59.37,20.19
VDD_1V8 on BOTTOM: 51.69,40.57 51.37,40.89 51.37,41.53 50.89,41.53 50.89,40.89 50.55,40.55 50.55,38.99 50.16,38.61 50.16,38.23 50.29,38.1 51.05,38.1 51.69,38.73
VDD_1V8 on BOTTOM: 19.3,11.18 19.3,13.21 19.56,13.46 20.7,13.46 21.72,12.45 21.72,9.53 22.1,9.14 22.1,7.75 21.59,7.75 21.59,8.89 21.21,9.27 19.81,9.27 19.81,10.67
VDD_1V8 on BOTTOM: 52.32,25.15 52.32,27.81 52.58,28.07 52.58,30.23 52.32,30.48 51.56,30.48 51.31,30.23 51.31,26.29 51.82,25.78 51.82,25.15
VDD_1V8 on BOTTOM: 42.42,27.69 43.18,27.69 43.43,27.94 43.43,28.7 43.69,28.96 45.09,28.96 45.34,29.21 45.34,29.59 45.47,29.72 45.72,29.72 45.85,29.84 45.85,30.48 45.72,30.61 45.09,30.61 44.32,31.37 43.43,31.37 43.18,31.11 43.18,30.35 42.93,30.1 42.29,30.1 42.29,27.81
VDD_1V8 on LYR3: 45.72,39.62 45.97,39.37 45.97,38.1 45.72,37.85 45.09,37.85 44.58,37.34 41.4,37.34 40.89,37.85 36.58,37.85 36.32,38.1 36.32,40.01 36.58,40.26 43.05,40.26 43.69,39.62
VDD_1V8 on LYR4: 52.45,30.1 52.2,29.84 51.69,29.84 51.44,30.1 51.44,30.48 51.31,30.61 49.91,30.61 49.28,29.97 45.47,29.97 45.21,30.23 45.21,33.53 44.96,33.78 43.81,33.78 43.56,34.04 43.56,39.37 43.81,39.62 52.2,39.62 52.45,39.37
VDD_1V8 on LYR5_PWR: 49.85,31.43 49.53,31.11 49.53,30.8 49.21,30.48 48.58,30.48 48.58,17.78 48.9,17.46 53.98,17.46 54.29,17.78 54.29,25.34 52.9,26.73 52.9,31.11 52.58,31.43
VDD_3V3A on BOTTOM: 43.69,34.8 44.2,34.8 44.58,34.42 44.58,34.16 44.83,33.91 45.47,33.91 45.72,33.66 45.72,32.64 45.21,32.64 45.21,33.02 44.83,33.4 44.32,33.4 44.07,33.66 42.42,33.66 42.42,34.16 43.05,34.16
VDD_3V3A on BOTTOM: 46.1,41.53 46.1,40.89 45.72,40.51 45.72,38.35 45.97,38.1 47.12,38.1 47.24,38.23 47.24,38.35 46.86,38.73 46.86,40.64 46.57,40.93 46.57,41.53
VDD_3V3A on BOTTOM: 51.94,38.1 53.85,38.1 54.1,38.35 54.1,40.26 54.57,40.72 54.57,41.53 54.1,41.53 54.1,40.89 53.72,40.51 53.72,38.99 53.34,38.99 53.34,40.51 52.96,40.89 52.96,41.53 52.5,41.53 52.5,40.94 52.07,40.51 52.07,38.73 51.82,38.48 51.82,38.23
VDD_3V3A on LYR5_PWR: 38.42,12.7 38.42,14.92 38.73,15.24 43.18,15.24 43.5,15.56 43.5,19.68 43.81,20 47.94,20 48.26,20.32 48.26,30.48 48.58,30.8 48.9,30.8 49.21,31.11 49.21,31.43 49.53,31.75 52.64,31.75 52.9,32 52.9,36.13 53.21,36.45 53.59,36.45 53.78,36.64 53.78,38.67 54.17,39.05 55.24,39.05 55.69,39.5 55.69,41.08 58.1,43.5 80.01,43.5 80.33,43.18 80.33,25.08 80.64,24.77 83.19,24.77 83.82,25.4 83.82,44.13 83.19,44.77 77.47,44.77 77.15,45.09 77.15,52.07 76.52,52.7 75.13,53.22 73.66,53.34 18.73,53.34 18.1,52.7 18.1,50.16 16.51,48.58 12.7,48.58 12.06,49.21 2.22,49.21 1.59,48.58 1.59,40.32 2.22,39.69 11.11,39.69 11.43,40.01 11.43,45.72 11.75,46.04 17.14,46.04 17.46,46.35 17.46,47.94 17.78,48.26 26.04,48.26 26.35,47.94 26.35,44.77 26.67,44.45 35.88,44.45 36.2,44.13 36.2,19.37 35.88,19.05 19.37,19.05 19.05,18.73 19.05,12.7 19.37,12.38 38.1,12.38
VDD_3V3B on LYR5_PWR: 10.16,3.49 12.7,6.03 16.51,6.03 18.1,4.45 18.1,1.91 18.73,1.27 73.98,1.27 75.27,1.51 76.52,1.91 77.15,2.54 77.15,8.26 76.52,8.89 74.61,8.89 73.98,9.53 73.98,11.11 74.61,11.75 83.19,11.75 83.82,12.38 83.82,21.27 83.19,21.91 54.86,21.91 54.61,21.65 54.61,17.46 54.29,17.14 48.58,17.14 48.26,17.46 48.26,19.37 47.94,19.68 44.13,19.68 43.81,19.37 43.81,15.24 43.5,14.92 39.05,14.92 38.73,14.61 38.73,12.38 38.42,12.06 19.05,12.06 18.73,12.38 18.73,19.05 19.05,19.37 35.56,19.37 35.88,19.68 35.88,43.81 35.56,44.13 26.35,44.13 26.04,44.45 26.04,47.62 25.72,47.94 18.1,47.94 17.78,47.62 17.78,46.04 17.46,45.72 12.06,45.72 11.75,45.4 11.75,39.69 12.7,38.73 12.7,37.15 13.34,36.51 24.13,36.51 24.77,35.88 24.77,28.57 24.45,28.26 21.27,28.26 18.73,25.72 18.73,24.45 17.46,23.18 13.34,23.18 12.7,22.54 12.7,20.95 11.75,20 2.54,20 1.91,19.37 1.91,5.4 3.81,3.49
VDD_5V on TOP (solid shape): 15.75,13.46 15.75,11.94 15.49,11.68 14.99,11.68 14.73,11.94 14.73,12.45 13.34,12.45 11.94,11.05 11.94,9.14 10.41,9.14 10.41,11.94 12.19,13.72 15.49,13.72
VDD_CORE on BOTTOM: 40.13,28.45 40.13,34.54 39.88,34.8 39.12,34.8 38.86,34.54 38.86,28.45 38.48,28.07 38.48,24 37.85,23.37 37.85,22.35 34.92,19.43 34.92,18.29 34.67,18.03 29.97,18.03 29.97,17.27 30.23,17.02 35.56,17.02 38.16,19.62 38.16,20.38 39.88,22.1 39.88,28.19
VDD_CORE on LYR3: 53.98,38.48 53.98,30.86 53.72,30.61 49.78,30.61 49.53,30.86 49.53,32 49.15,32.38 46.23,32.38 45.97,32.13 45.97,29.21 45.72,28.96 38.73,28.96 38.48,29.21 38.48,33.02 38.73,33.27 44.7,33.27 44.96,33.53 44.96,35.31 44.32,35.31 43.81,35.81 43.81,36.2 44.2,36.58 45.21,36.58 45.59,36.96 47.24,36.96 49.02,38.73 53.72,38.73
VDD_MPU on LYR3: 40.13,26.16 40.39,25.91 49.02,25.91 49.28,26.16 49.28,31.88 49.02,32.13 46.35,32.13 46.23,32 46.23,28.7 44.45,26.92 40.39,26.92 40.13,26.67
VDD_PHYA on LYR5_PWR: 24.45,28.89 24.13,28.57 20.95,28.57 18.41,26.04 18.41,24.77 17.14,23.5 10.48,23.5 9.21,22.23 2.54,22.23 1.91,22.86 1.91,28.26 2.54,28.89 2.54,30.8 1.91,31.43 1.91,36.83 2.54,37.47 9.21,37.47 10.48,36.2 23.81,36.2 24.45,35.56
VDD_PLL on BOTTOM: 47.75,41.53 47.75,40.89 47.37,40.51 47.37,38.61 47.88,38.1 48.01,38.1 48.9,38.99 48.9,39.24 48.51,39.62 48.51,40.51 48.13,40.89 48.13,41.53
VDD_PLL on BOTTOM: 42.29,33.15 42.93,33.15 43.05,33.27 44.58,33.27 44.83,33.02 44.83,32.38 44.58,32.13 43.43,32.13 42.93,32.64 42.29,32.64
VDD_PLL on LYR4: 43.56,33.27 44.7,33.27 44.96,33.02 44.96,32.38 44.7,32.13 42.42,32.13 42.16,32.38 42.16,36.7 42.29,36.83 43.18,36.83 43.31,36.7 43.31,33.53
VDDS_DDR on LYR5_PWR: 54.61,43.18 54.29,42.86 54.29,38.8 54.36,38.73 54.1,38.48 54.1,36.45 53.85,36.2 53.47,36.2 53.21,35.94 53.21,27.05 54.61,25.65 54.61,22.48 54.86,22.23 73.66,22.23 73.98,22.54 73.98,24.13 74.61,24.77 79.69,24.77 80.01,25.08 80.01,42.86 79.69,43.18
BAT on LYR3 (solid shape): 6.94,17.96 6.99,17.97 7.03,17.96 7.71,17.27 6.99,16.49 6.26,17.27
DC_IN on TOP: 20.96,14.22 21.76,15.01 21.76,15.2 21.72,15.24 18.03,15.24 17.27,14.48 17.27,12.45 17.02,12.19 16.13,12.19 16.13,11.43 16.51,11.43 16.76,11.18 17.53,11.18 18.54,12.19 18.54,13.97 18.79,14.22
P_L1 on TOP: 25.72,12.39 25.72,11.88 25.15,11.3 25.15,9.91 25.02,9.78 23.88,9.78 23.62,9.53 23.62,8.26 23.88,8 25.78,8 26.04,8.26 26.04,11.05 26.29,11.3 26.29,12.45 26.04,12.7
P_L2 on TOP: 27.71,12.42 27.81,12.19 28.04,12.09 28.32,11.81 28.32,9.02 28.07,8.76 27.56,8.76 27.3,9.02 27.3,11.43 27.05,11.68 27.05,12.83 27.15,12.92 27.3,12.92 27.71,12.52
P_L3 on TOP: 31.5,16.38 31.5,16.64 31.24,16.89 29.34,16.89 29.21,16.76 29.08,16.76 28.96,16.64 29.46,16.13 31.24,16.13
RXP on BOTTOM (solid shape): 14.62,34.29 13.89,33.58 13.21,34.25 13.2,34.29 13.21,34.33 13.89,35
VDCDC1 on TOP: 24.77,12.06 25.27,12.57 25.4,12.57 25.53,12.45 25.53,12.06 25.02,11.56 21.46,11.56 21.34,11.43 21.34,8.38 21.08,8.13 20.19,8.13 20.19,12.57 20.7,12.57 20.7,12.32 20.95,12.06
VDCDC2 on TOP: 28.32,13.72 29.46,12.57 30.86,12.57 30.99,12.45 30.99,8.89 30.86,8.76 30.23,8.76 29.97,9.02 29.97,11.43 29.84,11.56 29.34,11.56 28.43,12.47 28.32,12.7 28.09,12.8 27.81,13.08 27.56,13.08 27.56,13.72
VDCDC3 on TOP: 34.42,16.51 34.42,15.49 34.67,15.24 36.83,15.24 37.08,15.49 37.08,16.26 36.58,16.26 36.07,16.76 34.67,16.76
VRTC on LYR3: 52.32,29.72 51.56,29.72 51.31,29.46 51.31,26.54 51.05,26.29 51.05,26.04 52.7,26.04 52.7,26.23 52.77,26.3 52.77,26.35 52.58,26.54 52.58,29.46

Small or netless copper shapes (teardrops, artwork): 455 on TOP, 292 on BOTTOM, 208 on LYR3, 154 on LYR4

## Text on the board
BOTTOM: PCB RevC | LAYER 6 | SOLDER
Board Geometry/Soldermask Bottom: SMS
Ref Des/Silkscreen Bottom: S/N | BSLK
TOP: LAYER 1 | COMPONENT
Board Geometry/Soldermask Top: SMC
Ref Des/Silkscreen Top: USER LEDS | 2 | 3 | 0 | 1 | RESET | PWR | AM335x | USB Host | USB | Ethernet | microSD Card | TSLK
LYR2_GND: LAYER 2 | GROUND
LYR3: LAYER 3 | SIGNAL
LYR4: LAYER 4 | SIGNAL
LYR5_PWR: LAYER 5 | POWER
DISPLAY_BOTTOM: SPS
DIMENSION: (OZ) | LAYER 1 - PRIMARY SIDE - SIGNAL | LAYER 2 - GROUND PLANE | LAYER 3 - SIGNAL | LAYER 4 - SIGNAL | LAYER 5 - SPLIT POWER PLANE | LAYER 6 - SECONDARY SIDE - SIGNAL | LAYER# | COPPER WEIGHT | HALF+PLATING | IMPEDANCE CONTROL | +/- 10% | 50ohm SINGLE ENDED | TRACE WIDTH | TRACE WIDTH / SPACE | 90ohm DIFFERENTIAL | 100ohm DIFFERENTIAL | 10. ALL VIAS TO HAVE SOLDERMASK. | 9. PLATED THROUGH SLOT INDICATED WITH MULTIPLE DRILL HITS SHOULD BE | FINISHED AS SMOOTH WALL BY VEDOR. | PROCESS NOTES: | 2. APPLY LPI SOLDERMASK OVER BARE COPPER (SMOBC), | COLOR: BONE OR OFF WHITE. SOLDERMASK SHALL | CONFORM TO IPC-SM-840, CLASS H. CURRENT REV. | 3. SOLDERMASK ARTWORK HAS ZERO (0) OVERSIZED PADS. | FABRICATION VENDOR IS ALLOWED TO ADJUST THE COMPONENT | SOLDERMASK PADS TO MEET THEIR TOOLING REQUIREMENTS. | 4. APPLY LPI SILKSCREEN OR EQUIVALENT PER THE ARTWORK. | COLOR: BLACK. | 1. PLATE ALL EXPOSED AREAS WITH ELECTROLESS | IMMERSION GOLD, NICKEL 150 MICROINCHES THK MIN | GOLD 5-15 MICROINCHES THK MIN. | SUPPLIED IPC-D-356 NETLIST. | FAB NOTES: | 1. ALL DIMENSIONS ARE IN INCHES, UNLESS | OTHERWISE NOTED. | 2. THE PWB SHALL BE FABRICATED TO IPC-6012, | CLASS 2 AND WORKMANSHIP SHALL CONFORM TO | IPC-A-600, CLASS 2. CURRENT REVISIONS. | 3. BOARD MATERIAL SHALL BE 180 Tg/350 Td ISOLA FR-370HR | OR EQUIVALENT, RoHS COMPLIANT AND LEAD FREE | ASSEMBLY CAPABLE.  BOARD MATERIAL SHALL | MEET OR EXCEED IPC-4101B. COLOR: NATURAL. | 4. BOARD MATERIAL & CONSTRUCTION TO BE U.L. | APPROVED AND MARKED ON THE FINISHED BOARD. | 5. MINIMUM COPPER WALL THICKNESS OF PLATED-THRU | HOLES TO BE .001 INCH, WITH A MINIMUM | ANNULAR RING OF .002 INCH. | 6. OVERALL BOARD THICKNESS TO BE .062 +/- 10% | AND APPLIES AFTER ALL LAMINATION AND PLATING | PROCESSES, MEASURED FROM COPPER TO COPPER. | 7. MAX. WARP & TWIST TO BE .0075 INCHES PER INCH. | 8. BOARD MUST BE ELECTRICALLY TESTED USING | 1 | 5.25 | 4.75 | 4.5/6.5 | 5.0/7.0 | 3.75/7.25 | 4.00/8.00 | R.250 2X | LAYER STACK-UP - ALL DIMENSIONS IN INCHES
USER_PART_NUM_TOP: TSLKC
USER_PART_NUM_BOTTOM: BSLKC
DISPLAY_TOP: SPC
DEVICE_TYPE_TOP: DATE | DESIGN ENGR | PROJECT ENGR | ENGR MGR | NEXT ASSEMBLY | APPROVED | CHECKED | DRAFTING | ENGR | NONE | 1 OF 1
User.10: R206 | R207 | R139 | R137 | R135 | R132 | R153 | R205 | R209 | R201 | R56 | R55 | C65 | C90 | C96 | C92 | C93 | C91 | C39 | C37 | C33 | C60 | C58 | C62 | C47 | R146 | C36 | C73 | C80 | C78 | C81 | C71 | C48 | C49 | C76 | C77 | C79 | C63 | C61 | R127 | R126 | R198 | R5 | R212 | R214 | R213 | R162 | R18 | R141 | R143 | R122 | R125 | R124 | R123 | R211 | R200 | R136 | C25 | R20 | C157 | C10 | R131 | C123 | C125 | C124 | C18 | FB5 | C122 | C121 | C120 | C119 | C17 | C19 | R134 | R133 | R130 | R129 | R145 | R216 | R215 | R109 | R112 | R110 | R113 | R111 | C41 | C35 | R114 | C40 | C64 | C82 | R115 | C43 | C34 | C38 | C88 | C45 | R28 | R17 | R199 | C132 | R140 | R144 | R19 | C131 | R203 | C20 | R10 | R9 | R8 | R15 | R121 | C135 | C5 | C4 | D2 | D3 | D4 | D5 | S1 | USER LEDS | TP14 | D1 | 2 | 3 | 0 | 1 | RESET | C101 | TP10 | TP11 | TP12 | TP13 | R96 | R97 | R98 | R99 | FB4 | C100 | C144 | R160 | C137 | C145 | TP7 | 10 | 9 | TP15 | 21 | R208 | L1 | 15 | 7 | Y4 | TP8 | R158 | R154 | C146 | Q2 | L2 | R204 | TP4 | Q1 | U16 | U14 | U17 | L3 | R181 | R187 | C51 | C52 | 48 | 18 | R78 | 16 | 33 | 32 | Y1 | V | A | TP3 | TP1 | R69 | R68 | R47 | R46 | R67 | R59 | R72 | R71 | R54 | R53 | R52 | R70 | R25 | R63 | R73 | R64 | R38 | R42 | R34 | R61 | R60 | R36 | R76 | C116 | R | C133 | TP18 | C109 | C110 | C111 | C112 | C113 | C89 | 46 | 45 | C114 | C115 | C117 | C159 | C160 | R193 | U10 | U9 | C94 | 20 | R184 | C103 | C104 | C105 | C106 | C107 | R120 | C108 | C95 | R75 | R74 | 19 | R51 | R50 | R49 | R48 | R45 | R44 | R58 | R57 | R40 | R62 | R65 | R29 | R37 | R39 | R30 | R35 | R185 | R183 | R182 | C156 | R180 | R178 | R179 | C154 | R177 | R186 | C24 | C23 | R172 | R171 | R170 | R169 | R168 | R166 | R165 | FB6 | C46 | FB7 | Y3 | Y6 | C53 | C69 | C31 | C54 | C32 | FB1 | Y2 | U13 | R210 | R117 | R116 | C72 | C102 | C14 | R163 | C149 | R119 | R118 | C138 | C140 | C139 | R2 | C2 | C142 | R149 | R189 | R157 | Y5 | C126 | C127 | C128 | C130 | R142 | C129 | C7 | R150 | R138 | R128 | C3 | R16 | U7 | PWR | R27 | R23 | R155 | R159 | C136 | R156 | 22 | 28 | R12 | R161 | 14 | 8 | R188 | R173 | R174 | R13 | TP17 | C163 | 64 | 49 | C162 | C27 | R24 | R21 | C26 | C30 | C29 | C28 | C67 | R95 | R94 | R91 | C87 | 17 | R93 | R22 | R90 | TP6 | R92 | R89 | R88 | R87 | TP5 | R86 | R85 | R176 | R79 | R43 | R84 | R83 | R66 | R82 | R32 | R81 | R31 | R80 | C68 | R194 | R190 | R195 | R191 | R192 | R148 | C134 | R147 | R196 | R197 | C59 | C118 | R100 | R101 | R102 | R103 | R104 | R105 | R106 | R107 | R26 | R108 | R41 | C66 | R33 | R77 | C70 | C97 | C86 | C75 | FB2 | C98 | C83 | C147 | R164 | C151 | C164 | C85 | C99 | C84 | C42 | R175 | C56 | C57 | C161 | FB3 | C74 | C152 | C44 | C148 | R167 | C150 | C158 | FB8 | C21 | C153 | C155 | C22 | C15 | C50 | R7 | R4 | C55 | C9 | C8 | R11 | R1 | R151 | R14 | C141 | C16 | C143 | C165 | R3 | R152 | C6 | C1 | C166 | R6 | DATE | DESIGN ENGR | PROJECT ENGR | ENGR MGR | NEXT ASSEMBLY | APPROVED | CHECKED | DRAFTING | ENGR | 1 OF 1 | P5 | U1 | U8 | P6 | U11 | U2 | U15 | U5 | U12 | AM335x | U6 | P2 | P8 | P9 | USB Host | P4 | P7 | P3 | USB | Ethernet | P10 | microSD Card | S/N | ASSEMBLY SOLDER SIDE
User.11: NONE
User.24: FIGURE | 8.0 | 12.0 | 38.0 | 40.0 | 63.0 | 125.0 | 128.0 | 95.0x40.0 | 120.0x40.0 | 140.0x40.0 | DRILL CHART: TOP to BOTTOM | +3.0/-3.0 | +5.0/-5.0 | PLATED | NON-PLATED | 793 | 28 | 18 | 101 | 2 | 4 | 1 | SIZE | ALL UNITS ARE IN MILS | TOLERANCE | QTY
